options:
  parameters:
    author: Christer Bernérus, SM6FBQ
    category: Custom
    description: VHF-UHF transceiver with CW and SSB
    generate_options: qt_gui
    id: FBQ_xcvr_old
    output_language: python
    qt_qss_theme: /Users/bernerus/priv/proj/sdr/grc/FBQ_xcvr.qss
    realtime_scheduling: '1'
    title: SM6FBQ VHF transceiver
  states: {}

blocks:
- name: RX_power_offset_dB
  id: variable
  parameters:
    value: '-104'
  states: {}
- name: af_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 6, 2, 1, 1
    label: '  AF VOL'
    start: '0'
    step: '1'
    stop: '2000'
    value: '150'
    widget: dial
  states: {}
- name: af_right
  id: variable_qtgui_range
  parameters:
    gui_hint: 10, 1, 1, 2
    label: AF BAL
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
    widget: slider
  states: {}
- name: audio_samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: band_center
  id: variable
  parameters:
    value: (50.2e6, 50.45e6, 144.200e6,144.450e6, 432.2e6,432.45e6, 1296.4e6, 1296.850e6, preset_fq)
  states: {}
- name: band_chooser
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,7
    label: FREQUENCY BAND
    labels: '[''50'',''50 Fyr'', ''144'',''144 Fyr'',''432'',''432 Fyr'',''1296'',''1296 fyr'',''preset'']'
    num_opts: '0'
    options: '[0,1,2,3,4,5,6,7,8]'
    orient: Qt.QHBoxLayout
    type: int
    value: '8'
    widget: radio_buttons
  states: {}
- name: band_width
  id: variable
  parameters:
    value: (400e3, 100e3, 400e3,200e3, 400e3,100e3, 800e3, 200e3, 1000e3)
  states: {}
- name: bpf_high
  id: variable
  parameters:
    value: 3900,2900,2700,880,680
  states: {}
- name: bpf_low
  id: variable
  parameters:
    value: 100,100,100,380,480
  states: {}
- name: channel_delay
  id: variable_qtgui_range
  parameters:
    gui_hint: 11,1,1,2
    label: AF SYNC
    rangeType: int
    start: '-48000'
    step: '1'
    stop: '48000'
    value: '-17285'
  states: {}
- name: channel_separation
  id: variable
  parameters:
    value: '[100,100,10,10,1000,1000]'
  states: {}
- name: cw_level
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,6,1,1
    label: CW level
    start: '0'
    step: '0.01'
    stop: '0.95'
    value: '0.8'
    widget: dial
  states: {}
- name: cw_midear_beat
  id: variable
  parameters:
    value: 0,0,880,880,0,0
  states: {}
- name: cw_samp_rate
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: cw_txing
  id: variable
  parameters:
    value: '0'
  states: {}
- name: f0
  id: variable
  parameters:
    value: band_center[band_chooser] + freq
  states: {}
- name: fft_corr
  id: variable
  parameters:
    value: 0,0,880,0
  states: {}
- name: filter_freq
  id: variable
  parameters:
    value: 100e3+rit + tune + fine_tune
  states: {}
- name: fine_tune
  id: variable_qtgui_range
  parameters:
    gui_hint: 2, 0, 1, 5
    label: '  FINE TUNE'
    start: '-3000'
    step: '1'
    stop: '3000'
    value: '0'
  states: {}
- name: freq
  id: variable
  parameters:
    comment: From the waterfall. Bad name but hard to change it seems-
    value: '0'
  states: {}
- name: lna_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 5, 1, 1, 1
    label: RX LNA GAIN
    start: '0'
    step: '1'
    stop: '39'
    value: '39'
    widget: dial
  states: {}
- name: lsb_chain_gain
  id: variable
  parameters:
    value: 0,1,0,1,0,0
  states: {}
- name: mic_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,4,1,1
    label: MIC GAIN
    start: '0'
    step: '0.1'
    stop: '1.5'
    value: '1.4'
    widget: dial
  states: {}
- name: mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 5, 3, 2, 1
    label: MODE
    labels: '[''USB'',''LSB'',''CW'',''CW Stereo'', ''FT8'', ''MSK144'']'
    num_opts: '0'
    options: '[0, 1, 2,3,4,5]'
    type: int
    value: '5'
    widget: radio_buttons
  states: {}
- name: mode_to_sb
  id: variable
  parameters:
    value: '[0,1,2,3,0,0]'
  states: {}
- name: monitor
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 5, 4, 1, 1
    label: TRANSMIT SOUND
    label0: Monitor
    label1: RX/TX
    labels: '["MONITOR","RX / TX"]'
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '1'
    widget: radio_buttons
  states: {}
- name: morse_speed
  id: variable_qtgui_range
  parameters:
    comment: Morse speed in characters per minute, not WPM
    gui_hint: 8,6,1,1
    label: MORSE SPEED [CPM]
    start: '40'
    step: '1'
    stop: '200'
    value: '100'
  states: {}
- name: new_freq
  id: variable
  parameters:
    value: rx_in_freq
  states: {}
- name: new_tune
  id: variable
  parameters:
    value: new_freq - rx_center_freq - 100e3 - rit - fine_tune
  states: {}
- name: qtgui_levelgauge_0
  id: qtgui_levelgauge
  parameters:
    backgroundColor: silver
    barColor: teal
    fontColor: teal
    gui_hint: 6,0,1,2
    isVertical: 'False'
    label: S-meter [dBm]
    maximum: '30'
    minimum: '-140'
    showValue: 'True'
    type: real
    value: variable_function_probe_0
  states: {}
- name: qtgui_levelgauge_1
  id: qtgui_levelgauge
  parameters:
    maximum: '100'
    minimum: '0'
    type: int
    value: '0'
  states: {}
- name: rit
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    label: RIT
    start: '-rit_range[mode]'
    step: channel_separation[mode]
    stop: rit_range[mode]
    value: '0'
  states: {}
- name: rit_range
  id: variable
  parameters:
    value: '[5000,5000,1000,1000,48000,48000]'
  states: {}
- name: rx_bw
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3, 2, 2, 1
    label: RECEIVER BANDWIDTH - kHz
    label0: '3.9'
    label1: '3.2'
    label2: '2.7'
    label3: '0.5'
    label4: '0.05'
    labels: '[''3.9'',''2.7'',''0.5'',''0.2'']'
    num_opts: '5'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    option4: '4'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: rx_center_freq
  id: variable
  parameters:
    value: f0-100e3
  states: {}
- name: rx_corr
  id: variable
  parameters:
    value: 0,0,580,0
  states: {}
- name: rx_fq
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    ThousandsSeparator: '.'
    gui_hint: 3,0,1,2
    lbl: RECEIVE FQ
    maxFreqHz: 1700e6
    minFreqHz: 30e6
    outputmsgname: rx_freq
    relFontColor: green
    value: rx_center_freq+filter_freq
  states: {}
- name: rx_fq_1
  id: variable_qtgui_entry
  parameters:
    gui_hint: 13,0,1,2
    label: '                                          RECEIVE FQ'
    type: string
    value: '''{:.0f}''.format(new_tune)'
  states: {}
- name: rx_in_freq
  id: variable
  parameters:
    value: rx_center_freq+filter_freq
  states: {}
- name: rx_preamp
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 4,1,1,1
    label: RX Preamp
    label0: 'OFF'
    label1: 'ON'
    labels: '[''Barefoot'',''PA'']'
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: rx_samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sb_r
  id: variable
  parameters:
    value: '[-1,1,1,-1]'
  states: {}
- name: sb_t
  id: variable
  parameters:
    value: '[1,-1,1,1]'
  states: {}
- name: side_band
  id: variable
  parameters:
    value: mode_to_sb[mode]
  states: {}
- name: sq
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0,1,1
    label: SQUELCH
    start: '-110'
    step: '1'
    stop: '0'
    value: '-110'
    widget: slider
  states: {}
- name: ssb_drive
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,3,1,1
    label: SSB DRIVE
    start: '0'
    step: '1'
    stop: '100'
    value: '0.02'
  states: {state: disabled}
- name: ssb_tx_bandwidth
  id: variable
  parameters:
    value: tx_bw[tx_bw_opts]
  states: {}
- name: ssb_tx_mode
  id: variable
  parameters:
    value: 1,1,0,0
  states: {}
- name: ssb_txing
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ssb_txing_btn
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 2,5,1,2
    label: PTT
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '300'
  states: {}
- name: tit
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,4,1,2
    label: TIT
    start: '-1000'
    step: '1'
    stop: '1000'
    value: '0'
  states: {}
- name: tune
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0, 1, 5
    label: '  TUNE'
    start: '-band_width[band_chooser]/2'
    step: band_width[band_chooser]/200
    stop: band_width[band_chooser]/2
    value: '0'
  states: {}
- name: tx_bw
  id: variable
  parameters:
    value: '[5000.0,3500.0,2500.0,1750.0]'
  states: {}
- name: tx_bw_opts
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3, 3, 2, 1
    label: TRANSMITTER BANDWIDTH - kHz
    label0: '5'
    label1: '3.5'
    label2: '2.5'
    label3: '1.75'
    labels: '[''3.9'',''2.7'',''0.5'',''0.2'']'
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    type: int
    value: '1'
    widget: radio_buttons
  states: {}
- name: tx_center_fq
  id: variable
  parameters:
    value: (f0 + tune + fine_tune)
  states: {}
- name: tx_fq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 3,4,1,2
    label: '                                          TRANSMIT FQ'
    type: string
    value: '''{:.0f}''.format(tx_center_fq)'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    comment: Determines the transmit gain setting for the HackRF.
    gui_hint: 7,3,1,1
    label: TX GAIN
    start: '0'
    step: '1'
    stop: '47'
    value: '47'
    widget: dial
  states: {}
- name: tx_mode_offset
  id: variable
  parameters:
    value: '[tx_bw[tx_bw_opts], -tx_bw[tx_bw_opts], 0, 0, [tx_bw_opts],[tx_bw_opts]]'
  states: {}
- name: tx_pwr
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,3,1,1
    label: TX PWR
    start: '0'
    step: '1'
    stop: '100'
    value: '0.00'
  states: {state: disabled}
- name: tx_samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: txing
  id: variable
  parameters:
    value: cw_txing or ssb_txing
  states: {}
- name: usb_chain_gain
  id: variable
  parameters:
    value: 1,0,1,1,1,1
  states: {}
- name: variable_function_probe_0
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_0
    function_name: level
    poll_rate: '35'
    value: '0'
  states: {}
- name: vga_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 5, 2, 1, 1
    label: RX VGA Gain
    start: '0'
    step: '1'
    stop: '61'
    value: '53'
    widget: dial
  states: {}
- name: vox_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,5,1,1
    label: VOX SENS
    start: '0'
    step: '1'
    stop: '200'
    value: '50'
    widget: dial
  states: {}
- name: wf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 8,2,1,1
    label: Waterfall gain
    start: '0'
    step: '1'
    stop: '100'
    value: '1'
    widget: dial
  states: {}
- name: Source_freq
  id: note
  parameters:
    note: lo_freq_Hz[freq_chooser]-10e3-100
  states: {}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: (1e-1)
    decay_rate: '3e-6'
    gain: '.1'
    iir_update_decim: '1'
    max_gain: '.1'
    reference: (.001)*0+.002
    type: complex
  states: {}
- name: analog_agc3_xx_0_0
  id: analog_agc3_xx
  parameters:
    attack_rate: (1e-1)
    decay_rate: '3e-6'
    gain: '.1'
    iir_update_decim: '1'
    max_gain: '.1'
    reference: (.001)*0+.002
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: cw_midear_beat[side_band]
    offset: '0'
    phase: '0'
    samp_rate: 48e3
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: ssb_tx_bandwidth
    offset: '0'
    phase: '0'
    samp_rate: audio_samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: ssb_tx_bandwidth
    offset: '0'
    phase: '0'
    samp_rate: audio_samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_3_0
  id: analog_sig_source_x
  parameters:
    amp: '0.85'
    freq: '2000'
    offset: '0'
    phase: '0'
    samp_rate: 48e3
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '.001'
    threshold: sq
  states: {}
- name: analog_simple_squelch_cc_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '.001'
    threshold: sq
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: '"WSJT-3"'
    num_inputs: '2'
    samp_rate: audio_samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: '"BlackHole 16ch"'
    samp_rate: audio_samp_rate
  states: {}
- name: audio_source_0_0
  id: audio_source
  parameters:
    device_name: '"BlackHole 16ch"'
    samp_rate: audio_samp_rate
  states: {state: disabled}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '2700'
    low_cutoff_freq: '200'
    samp_rate: audio_samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '2'
    gain: '1'
    high_cutoff_freq: bpf_high[rx_bw]
    low_cutoff_freq: bpf_low[rx_bw]
    samp_rate: '100000'
    type: fir_filter_ccc
    width: '100'
    win: window.WIN_BLACKMAN
  states: {}
- name: band_pass_filter_0_1
  id: band_pass_filter
  parameters:
    decim: '2'
    gain: '1'
    high_cutoff_freq: bpf_high[rx_bw]
    low_cutoff_freq: bpf_low[rx_bw]
    samp_rate: '100000'
    type: fir_filter_ccc
    width: '100'
    win: window.WIN_BLACKMAN
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_float_0_1_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_2
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_2_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_2_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '20'
    type: float
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: max(channel_delay,0)
    type: float
  states: {}
- name: blocks_delay_1_0
  id: blocks_delay
  parameters:
    delay: '-min(channel_delay, 0)'
    type: float
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_complex_0_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_1_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_1_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_3
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: 50000*5
    type: float
  states: {}
- name: blocks_integrate_xx_1
  id: blocks_integrate_xx
  parameters:
    decim: '50'
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '480'
    scale: 1/10
    type: float
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: cw_txing
  states: {}
- name: blocks_msgpair_to_var_0_0
  id: blocks_msgpair_to_var
  parameters:
    target: ssb_txing
  states: {}
- name: blocks_msgpair_to_var_2
  id: blocks_msgpair_to_var
  parameters:
    target: freq
  states: {}
- name: blocks_msgpair_to_var_3
  id: blocks_msgpair_to_var
  parameters:
    target: new_freq
  states: {state: disabled}
- name: blocks_msgpair_to_var_4
  id: blocks_msgpair_to_var
  parameters:
    target: tune
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: monitor
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: mic_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: vox_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3
  id: blocks_multiply_const_vxx
  parameters:
    const: af_gain*(1-af_right)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3_0
  id: blocks_multiply_const_vxx
  parameters:
    const: af_gain *af_right
    type: float
  states: {}
- name: blocks_multiply_const_vxx_4_0
  id: blocks_multiply_const_vxx
  parameters:
    const: lsb_chain_gain[side_band]
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_4_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: usb_chain_gain[side_band]
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_4_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: wf_gain
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: RX_power_offset_dB
    n: '10.6'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_3
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_source_1
  id: blocks_null_source
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_probe_signal_x_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '3000'
    type: byte
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    comment: output samp rate = 3 MHz
    interp: int(tx_samp_rate/cw_samp_rate)
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: (ssb_txing or ssb_txing_btn)
    type: complex
  states: {}
- name: blocks_selector_0_x
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: side_band
    maxoutbuf: '2'
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_y
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: side_band
    maxoutbuf: '2'
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: side_band
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_2
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(cw_txing)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_3
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(cw_txing)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: audio_samp_rate
    type: float
  states: {state: disabled}
- name: blocks_throttle_1_0
  id: blocks_throttle
  parameters:
    samples_per_second: '48000'
    type: float
  states: {state: disabled}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Stream gate - with gate open output=input, with gate closed input is simply consumed"""

          def __init__(self, gate=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Stream gate',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.gate = gate

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              if self.gate:
                  output_items[0][:] = input_items[0]
                  self.consume(0, len(input_items[0]))
                  return len(output_items[0])
              else:
                  self.consume(0, len(input_items[0]))
                  return 0
    gate: ssb_txing
  states: {state: disabled}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Morse code vector source
      """

      #  epy_block_0.py
      #  revised 09/10/2019 - finish code table
      #  revised 09/11/2019 - test for bad character
      #  revised 09/27/2019 - get input from a Message Edit block (code from Volker Schroer dl1ksv)

      import numpy as np
      from gnuradio import gr

      import pmt

      textboxValue = ""

      Morse = {
          # codes from https://www.itu.int/rec/R-REC-M.1677-1-200910-I/en
          "A": "10111",
          "B": "111010101",
          "C": "11101011101",
          "D": "1110101",
          "E": "1",
          "F": "101011101",
          "G": "111011101",
          "H": "1010101",
          "I": "101",
          "J": "1011101110111",
          "K": "111010111",
          "L": "101110101",
          "M": "1110111",
          "N": "11101",
          "O": "11101110111",
          "P": "10111011101",
          "Q": "1110111010111",
          "R": "1011101",
          "S": "10101",
          "T": "111",
          "U": "1010111",
          "V": "101010111",
          "W": "101110111",
          "X": "11101010111",
          "Y": "1110101110111",
          "Z": "11101110101",
          "Å": "101110111010111",
          "Ä": "10111010111",
          "Ö": "1110111011101",
          " ": "0",
          "1": "10111011101110111",
          "2": "101011101110111",
          "3": "1010101110111",
          "4": "10101010111",
          "5": "101010101",
          "6": "11101010101",
          "7": "1110111010101",
          "8": "111011101110101",
          "9": "11101110111011101",
          "0": "1110111011101110111",
          ".": "10111010111010111",  # period
          ",": "1110111010101110111",  # comma
          ":": "11101110111010101",  # colon
          "?": "101011101110101",  # question
          "'": "1011101110111011101",  # apostrophe
          "-": "111010101010111",  # dash or minus
          "/": "1110101011101",  # slash
          "(": "111010111011101",  # left parenthesis
          ")": "1110101110111010111",  # right parenthesis
          "\"": "101110101011101",  # quote
          "=": "1110101010111",  # equals
          "+": "1011101011101",  # plus
          "@": "10111011101011101",  # at sign (@)
          # these punctuation marks are not included in the ITU recommendation
          # but are found in https://en.wikipedia.org/wiki/Morse_code
          "!": "1110101110101110111",  # exclamation point
          "&": "10111010101",  # ampersand (also prosign for 'WAIT')
          ";": "11101011101011101",  # semicolon
          "_": "10101110111010111",  # underscore
          "$": "10101011101010111"  # dollar sign
      }


      class mc_sync_block(gr.sync_block):
          """
          reads input from a message port
          generates a vector of Morse code bits
          """

          def __init__(self):
              gr.sync_block.__init__(self,
                                     name="Morse code vector source",
                                     in_sig=None,
                                     out_sig=[np.byte])
              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_out(pmt.intern('clear_input'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)
              self.textboxValue = None

          def handle_msg(self, msg):
              global textboxValue
              self.textboxValue = pmt.symbol_to_string(msg)
              # print(textboxValue)

          def work(self, input_items, output_items):

              nbit_stream = ""

              if not self.textboxValue:
                  return 0

              for ch in self.textboxValue:
                  nbit_stream += (Morse.get(ch.upper()) if ch.upper() in Morse else Morse.get('?')) + "000"
              nbit_stream += "0000"

              for x in range(len(nbit_stream)):
                  output_items[0][x] = int(nbit_stream[x])

              # clear input line
              self.textboxValue = ""
              self.message_port_pub(pmt.intern('clear_input'), pmt.intern(''))
              return len(nbit_stream)
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Stream gate - with gate open output=input, with gate closed input is simply consumed"""

          def __init__(self, gate=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Stream gate',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.gate = gate

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              if self.gate:
                  output_items[0][:] = input_items[0]
                  self.consume(0, len(input_items[0]))
                  return len(output_items[0])
              else:
                  self.consume(0, len(input_items[0]))
                  return 0
    gate: '1'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import threading
      import typing as T

      import numpy as np
      import pmt
      from gnuradio import gr
      import time


      class one_shot:

          def __init__(self, delay: float, callback: T.Callable):
              self.delay = delay
              self.timer = None
              self.callback = callback
              self.last_start = None
              self.to_sleep = None
              self.thread = None

          def countdown(self):
              now = time.time_ns()
              if self.to_sleep is None:
                  self.last_start = None
                  #print("Timer timed out, at %d last_start is now %s" % (now, self.last_start))
                  self.timer.cancel()
                  self.callback()
                  return
              self.timer = threading.Timer(self.to_sleep, self.countdown)
              self.timer.start()
              self.last_start = now
              print("Timer restarted at %d for %f seconds" % (self.last_start, self.to_sleep))
              self.to_sleep = None

          def trigger(self):
              now = time.time_ns()
              if self.last_start is None:
                  self.to_sleep = self.delay
                  self.timer = threading.Timer(self.to_sleep, self.countdown)
                  self.timer.start()
                  self.last_start = now
                  #print("Timer started at %d for %f seconds" % (self.last_start, self.to_sleep))
                  self.to_sleep = None
                  return
              else:
                  #print("Trig, last_start=%f" % self.last_start)
                  self.to_sleep = (now - self.last_start) / 1000000000
                  #print("Timer retrig at %d, To_sleep = %f" % (now, self.to_sleep))


      # noinspection PyPep8Naming
      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """VOX detector - sends a message when detecting a signal and another some time after the signal has been absent
             threshold is the signal level needed to trigger an on-air message
             attack is the number of consecutive samples needed before the message is sent
             delay is the number of seconds after the last sample over the threshold level that the off-air
             message is sent.

             The on-air message is represented by the message pair ("onair", 1) and the off-air message is represented by the
             message pair ("onair", 0)

             The output stream contains 100 zeros if the last message sent is am off-air message and 100 ones
             if the last message sent is a on-air message. Whenever a message is sent a ramp string of samples
             are sent, going from 0 to 1 on any on-air signal and from 1 to 0 on any off-air signal.

             Note that the incoming stream needs to represent the volume level of the audio, not the audio samples themselves.

             """

          def __init__(self, threshold=5, attack=10, delay=0.5):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='VOX detector',  # will show up in GRC
                  in_sig=[np.ubyte],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.threshold = threshold
              self.attack = attack
              self.delay = delay

              self.attack_counter = attack  # Counts down to 0
              self.one_shot = None
              self.message_port_register_out(pmt.intern("onair"))
              self.onair = False
              # self.to_output = []

          def send_onair_message(self):
              if not self.onair:
                  self.message_port_pub(pmt.intern("onair"), pmt.cons(pmt.string_to_symbol("onair"), pmt.to_pmt(1)))
                  self.onair = True
                  # self.ramp_up()

          def send_offair_message(self):
              if self.onair:
                  self.message_port_pub(pmt.intern("onair"), pmt.cons(pmt.string_to_symbol("onair"), pmt.to_pmt(0)))
                  self.onair = False
                  # self.ramp_down()

          def ramp_up(self):
              self.to_output = []
              for i in range(0, 128):
                  self.to_output.append(i/128)

          def ramp_down(self):
              self.to_output = []
              for i in range(0, 100):
                  self.to_output.append(1 - i/128)


          def work(self, input_items, output_items):
              #print("Input0(%d)=" % len(input_items[0]), input_items[0])
              # print("Output0(%d)=" % len(output_items[0]), output_items[0])
              for item in input_items[0]:
                  if item is not None:
                      item = -item if item < 0 else item
                      if item > self.threshold:
                          self.attack_counter -= 1
                          if self.attack_counter <= 0:
                              self.send_onair_message()
                              self.trigger_one_shot()
                              self.attack_counter = self.attack
                      else:
                          self.attack_counter = self.attack
              else:
                  self.attack_counter = self.attack

              self.consume(0, len(input_items[0]))
              # self.produce(0, 128)
              # output_items[0] = self.to_output
              # self.to_output = [1 if self.onair else 0 for i in range(0, 128)]

              # return len(output_items[0])
              return 0

          def trigger_one_shot(self):
              if self.one_shot is None:
                  self.one_shot = one_shot(self.delay, self.send_offair_message)
                  #print("Oneshot created")
              self.one_shot.trigger()
              #print("Oneshot triggered")
    attack: '10'
    delay: 6/morse_speed * 25
    threshold: '0.8'
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import threading
      import typing as T

      import numpy as np
      import pmt
      from gnuradio import gr
      import time


      class one_shot:

          def __init__(self, delay: float, callback: T.Callable):
              self.delay = delay
              self.timer = None
              self.callback = callback
              self.last_start = None
              self.to_sleep = None
              self.thread = None

          def countdown(self):
              now = time.time_ns()
              if self.to_sleep is None:
                  self.last_start = None
                  #print("Timer timed out, at %d last_start is now %s" % (now, self.last_start))
                  self.timer.cancel()
                  self.callback()
                  return
              self.timer = threading.Timer(self.to_sleep, self.countdown)
              self.timer.start()
              self.last_start = now
              #print("Timer restarted at %d for %f seconds" % (self.last_start, self.to_sleep))
              self.to_sleep = None

          def trigger(self):
              now = time.time_ns()
              if self.last_start is None:
                  self.to_sleep = self.delay
                  self.timer = threading.Timer(self.to_sleep, self.countdown)
                  self.timer.start()
                  self.last_start = now
                  #print("Timer started at %d for %f seconds" % (self.last_start, self.to_sleep))
                  self.to_sleep = None
                  return
              else:
                  #print("Trig, last_start=%f" % self.last_start)
                  self.to_sleep = (now - self.last_start) / 1000000000
                  #print("Timer retrig at %d, To_sleep = %f" % (now, self.to_sleep))


      # noinspection PyPep8Naming
      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """VOX detector - sends a message when detecting a signal and another some time after the signal has been absent
             threshold is the signal level needed to trigger an on-air message
             attack is the number of consecutive samples needed before the message is sent
             delay is the number of seconds after the last sample over the threshold level that the off-air
             message is sent.

             The on-air message is represented by the message pair ("onair", 1) and the off-air message is represented by the
             message pair ("onair", 0)

             The output stream contains 100 zeros if the last message sent is am off-air message and 100 ones
             if the last message sent is a on-air message. Whenever a message is sent a ramp string of samples
             are sent, going from 0 to 1 on any on-air signal and from 1 to 0 on any off-air signal.

             Note that the incoming stream needs to represent the volume level of the audio, not the audio samples themselves.

             """

          def __init__(self, threshold=5, attack=10, delay=0.5):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='VOX detector',  # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.threshold = threshold
              self.attack = attack
              self.delay = delay

              self.attack_counter = attack  # Counts down to 0
              self.one_shot = None
              self.message_port_register_out(pmt.intern("onair"))
              self.onair = False
              # self.to_output = []

          def send_onair_message(self):
              if not self.onair:
                  self.message_port_pub(pmt.intern("onair"), pmt.cons(pmt.string_to_symbol("onair"), pmt.to_pmt(1)))
                  self.onair = True
                  # self.ramp_up()

          def send_offair_message(self):
              if self.onair:
                  self.message_port_pub(pmt.intern("onair"), pmt.cons(pmt.string_to_symbol("onair"), pmt.to_pmt(0)))
                  self.onair = False
                  # self.ramp_down()

          def ramp_up(self):
              self.to_output = []
              for i in range(0, 128):
                  self.to_output.append(i/128)

          def ramp_down(self):
              self.to_output = []
              for i in range(0, 100):
                  self.to_output.append(1 - i/128)


          def work(self, input_items, output_items):
              # print("Input0(%f)=" % len(input_items[0]), input_items[0])
              # print("Output0(%d)=" % len(output_items[0]), output_items[0])
              for item in input_items[0]:
                  if item is not None:
                      item = -item if item < 0 else item
                      if item > self.threshold:
                          self.attack_counter -= 1
                          if self.attack_counter <= 0:
                              self.send_onair_message()
                              self.trigger_one_shot()
                              self.attack_counter = self.attack
                      else:
                          self.attack_counter = self.attack
              else:
                  self.attack_counter = self.attack

              self.consume(0, len(input_items[0]))
              # self.produce(0, 128)
              # output_items[0] = self.to_output
              # self.to_output = [1 if self.onair else 0 for i in range(0, 128)]

              # return len(output_items[0])
              return 0

          def trigger_one_shot(self):
              if self.one_shot is None:
                  self.one_shot = one_shot(self.delay, self.send_offair_message)
                  # print("Oneshot created")
              self.one_shot.trigger()
              # print("Oneshot triggered")
    attack: '10'
    delay: '0.8'
    threshold: '2'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: "\n\nfrom gnuradio import gr\nimport pmt\n\nclass var_to_msg_pair_ref(gr.sync_block):\n    \"\"\"\n    This block has a callback that will emit a message pair with the updated variable\n    value when called. This is useful for monitoring a GRC variable and emitting a message\n    when it is changed.\n    \"\"\"\n    def __init__(self, pairname=None, check_var = None, ref_var=None):\n        gr.sync_block.__init__(self, name=\"Variable to message on diff\", in_sig=None, out_sig=None)\n\n        self.pairname = pairname\n        self.check_var = check_var\n        self.ref_var = ref_var\n\n        self.message_port_register_out(pmt.intern(\"msgout\"))\n\n    def variable_changed(self, value):\n        if self.monitor_var == self.ref_var:\n            return\n        try:\n            if type(value) is float:\n                p = pmt.from_double(value)\n            elif type(value) is int:\n                p = pmt.from_long(value)\n            elif type(value) is bool:\n                p = pmt.from_bool(value)\n            elif type(value) is str:\n                p = pmt.intern(value)\n            else:\n                p = pmt.to_pmt(value)\n\n            self.message_port_pub(pmt.intern(\"msgout\"), pmt.cons(pmt.intern(self.pairname), p))\n\n        except Exception as e:\n            gr.log.error(\"Unable to convert \" + repr(value) + \" to PDU, no message will be emitted (reason: %s)\" % repr(e))\n\n\n    def stop(self):\n        return True"
    check_var: rx_fq
    pairname: '''freq'''
    ref_var: rx_center_freq+filter_freq
  states: {}
- name: freq_xlating_fft_filter_ccc_1
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: filter_freq+cw_midear_beat[side_band]
    decim: '1'
    nthreads: '2'
    samp_rate: rx_samp_rate
    taps: firdes.low_pass(1,rx_samp_rate,rx_samp_rate/(2*1),4000)
  states: {}
- name: freq_xlating_fft_filter_ccc_1_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: filter_freq-cw_midear_beat[side_band]
    decim: '1'
    nthreads: '2'
    samp_rate: rx_samp_rate
    taps: firdes.low_pass(1,rx_samp_rate,rx_samp_rate/(2*1),4000)
  states: {}
- name: frequency_counter
  id: note
  parameters:
    note: '''{:.0f}''.format((lo_freq_Hz[freq_chooser]+tune+fine_tune))'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: ssb_tx_bandwidth
    decim: '2'
    gain: '1'
    samp_rate: audio_samp_rate
    type: fir_filter_fff
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: ssb_tx_bandwidth
    decim: '2'
    gain: '1'
    samp_rate: audio_samp_rate
    type: fir_filter_fff
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: audio_samp_rate/cw_samp_rate
    type: float
  states: {}
- name: mulc_lsb1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: mulc_lsb_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: mulc_usb1
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: mulc_usb_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: note_0
  id: note
  parameters:
    note: SSB RECEIVER SECTION
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: USB RX chain
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: LSB RX chain
  states: {}
- name: note_1
  id: note
  parameters:
    note: SSB TRANSMITTER SECTION
  states: {}
- name: note_2
  id: note
  parameters:
    note: CW transmiter section
  states: {}
- name: note_3
  id: note
  parameters:
    note: S meter
  states: {}
- name: note_4
  id: note
  parameters:
    note: SET FREQUENCY
  states: {}
- name: note_5
  id: note
  parameters:
    note: CONTROL SECTION
  states: {}
- name: pfb_decimator_ccf_0_0
  id: pfb_decimator_ccf
  parameters:
    atten: '60'
    channel: '0'
    decim: int(rx_samp_rate/100000)
    taps: firdes.low_pass(1,rx_samp_rate/2, 3900,100)
  states: {}
- name: pfb_decimator_ccf_0_0_0
  id: pfb_decimator_ccf
  parameters:
    atten: '60'
    channel: '0'
    decim: int(rx_samp_rate/100000)
    taps: firdes.low_pass(1,rx_samp_rate/2, 3900,100)
  states: {}
- name: pfb_decimator_ccf_0_1
  id: pfb_decimator_ccf
  parameters:
    atten: '100'
    channel: '0'
    decim: ' 3*int(rx_samp_rate/1000000)'
    taps: firdes.low_pass(.028,rx_samp_rate/32,5000,100)
  states: {}
- name: preset_fq
  id: parameter
  parameters:
    label: PRESET FREQUENCY
    value: 144.174e6
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 8,3,1,3
    is_pair: 'False'
    label: 'CW message to send:'
    type: string
  states: {}
- name: qtgui_edit_box_msg_1
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 9,2,1,1
    is_static: 'False'
    label: WF Frequency
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: band_width[band_chooser]
    ctrlpanel: 'True'
    fc: fft_corr[side_band]
    fftsize: '1024'
    grid: 'True'
    gui_hint: 5,0,1,1
    label: Relative signal
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '10000'
    fc: '0'
    fftsize: '2048'
    type: float
    wintype: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_ledindicator_0
  id: qtgui_ledindicator
  parameters:
    gui_hint: 1,6,1,1
    label: ON AIR CW
    offColor: black
    onColor: red
    state: cw_txing
  states: {}
- name: qtgui_ledindicator_0_0
  id: qtgui_ledindicator
  parameters:
    gui_hint: 1,5,1,1
    label: ON AIR SSB
    offColor: black
    onColor: red
    state: (ssb_txing or ssb_txing_btn)
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: band_width[band_chooser]
    fc: fft_corr[side_band]
    fftsize: '1024'
    plotconst: 'False'
    showports: 'True'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    nconnections: '2'
    size: '65536'
    srate: 48e3
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    update_time: '0.05'
    ymax: '1.5'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: band_width[band_chooser]
    fc: fft_corr[side_band]
    fftsize: '1024'
    grid: 'True'
    gui_hint: 8,0,2,2
    int_min: '-100'
    label1: Line 1 label
    showports: 'True'
    type: complex
    wintype: window.WIN_HANN
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    fbw: '0.4'
    interp: '48'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    fbw: '0.4'
    interp: '48'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '24'
    type: fff
  states: {state: disabled}
- name: rational_resampler_xxx_4_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(2*tx_samp_rate/audio_samp_rate)
    type: ccc
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '200'
    samp_rate: cw_samp_rate
    sym_rate: symbol_rate
    type: fir_filter_fff
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: cw_level
    ntaps: '200'
    samp_rate: cw_samp_rate
    sym_rate: symbol_rate
    type: fir_filter_fff
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    amp: 'True'
    bandwidth: tx_bw[tx_bw_opts]
    center_freq: tx_center_fq+tx_mode_offset[side_band]
    dev_args: driver=remote,remote=tcp://192.168.1.125:1234,remote:type=hackrf
    samp_rate: tx_samp_rate
    type: fc32
    vga: tx_gain
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: rx_preamp
    center_freq: rx_center_freq
    dev_args: driver=remote,remote=tcp://192.168.1.125:1234,remote:type=hackrf
    gain: lna_gain
    samp_rate: rx_samp_rate
    type: fc32
    vga: vga_gain
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx_monitor
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: rrc
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: af_l
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: af_r
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tx_monitor
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: rrc
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: af_l
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: af_r
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:50251
    timeout: '100'
  states: {state: disabled}

connections:
- [analog_agc3_xx_0, '0', rational_resampler_xxx_0, '0']
- [analog_agc3_xx_0_0, '0', rational_resampler_xxx_0_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0_0, '0']
- [analog_sig_source_x_1_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_3_0, '0', blocks_throttle_1_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_agc3_xx_0, '0']
- [analog_simple_squelch_cc_0_0, '0', analog_agc3_xx_0_0, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_1_0_0_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_1_0_0_1, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_0_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_0_0_0, '1']
- [band_pass_filter_0, '0', blocks_throttle_0, '0']
- [band_pass_filter_0_0, '0', blocks_complex_to_float_0_1_0, '0']
- [band_pass_filter_0_1, '0', blocks_complex_to_float_0_2_0_0, '0']
- [blocks_add_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_complex_to_float_0_1_0, '0', blocks_float_to_complex_0_0_0, '1']
- [blocks_complex_to_float_0_1_0, '1', mulc_lsb1, '0']
- [blocks_complex_to_float_0_2, '0', blocks_float_to_complex_0_1, '1']
- [blocks_complex_to_float_0_2, '1', mulc_lsb_0, '0']
- [blocks_complex_to_float_0_2_0, '0', blocks_float_to_complex_0_1_0, '1']
- [blocks_complex_to_float_0_2_0, '1', mulc_usb_0, '0']
- [blocks_complex_to_float_0_2_0_0, '0', blocks_float_to_complex_0_1_0_0, '1']
- [blocks_complex_to_float_0_2_0_0, '1', mulc_usb1, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_complex_to_real_0, '0', blocks_delay_1, '0']
- [blocks_complex_to_real_0_0_0, '0', blocks_delay_1_0, '0']
- [blocks_delay_0, '0', blocks_float_to_complex_0_3, '0']
- [blocks_delay_0, '0', mmse_resampler_xx_0, '0']
- [blocks_delay_1, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_delay_1_0, '0', blocks_multiply_const_vxx_1_0_1, '0']
- [blocks_float_to_char_0, '0', epy_block_1, '0']
- [blocks_float_to_complex_0_0_0, '0', analog_simple_squelch_cc_0, '0']
- [blocks_float_to_complex_0_0_0, '0', blocks_add_xx_0, '1']
- [blocks_float_to_complex_0_0_1, '0', blocks_selector_0, '0']
- [blocks_float_to_complex_0_1, '0', band_pass_filter_0_0, '0']
- [blocks_float_to_complex_0_1_0, '0', band_pass_filter_0_1, '0']
- [blocks_float_to_complex_0_1_0_0, '0', analog_simple_squelch_cc_0_0, '0']
- [blocks_float_to_complex_0_1_0_0, '0', blocks_add_xx_0, '0']
- [blocks_float_to_complex_0_3, '0', blocks_repeat_0_0, '0']
- [blocks_float_to_complex_0_3, '0', epy_block_0_1, '0']
- [blocks_integrate_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_integrate_xx_1, '0', blocks_float_to_char_0, '0']
- [blocks_moving_average_xx_0, '0', epy_block_1_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_selector_0_x, '1']
- [blocks_multiply_const_vxx_1, '0', blocks_selector_0_x, '3']
- [blocks_multiply_const_vxx_1, '0', blocks_selector_0_y, '1']
- [blocks_multiply_const_vxx_1_0_0_0, '0', band_pass_filter_0, '0']
- [blocks_multiply_const_vxx_1_0_0_1, '0', blocks_moving_average_xx_0, '0']
- [blocks_multiply_const_vxx_1_0_1, '0', blocks_selector_0_x, '0']
- [blocks_multiply_const_vxx_1_0_1, '0', blocks_selector_0_x, '2']
- [blocks_multiply_const_vxx_1_0_1, '0', blocks_selector_0_y, '0']
- [blocks_multiply_const_vxx_1_0_1, '0', blocks_selector_0_y, '2']
- [blocks_multiply_const_vxx_1_0_1, '0', blocks_selector_0_y, '3']
- [blocks_multiply_const_vxx_3, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_3_0, '0', audio_sink_0, '1']
- [blocks_multiply_const_vxx_4_0, '0', blocks_complex_to_float_0_2, '0']
- [blocks_multiply_const_vxx_4_0_0, '0', blocks_complex_to_float_0_2_0, '0']
- [blocks_multiply_const_vxx_4_0_0_0, '0', pfb_decimator_ccf_0_1, '0']
- [blocks_multiply_const_vxx_4_0_0_0, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_const_vxx_4_0_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_probe_signal_x_0, '0']
- [blocks_null_source_1, '0', blocks_multiply_const_vxx_1_0_0_0, '0']
- [blocks_repeat_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_repeat_0_0, '0', blocks_null_sink_0, '0']
- [blocks_repeat_0_0, '0', blocks_selector_1, '2']
- [blocks_repeat_0_0, '0', blocks_selector_1, '3']
- [blocks_selector_0, '0', blocks_null_sink_2, '0']
- [blocks_selector_0, '1', rational_resampler_xxx_4_0, '0']
- [blocks_selector_0_x, '0', virtual_sink_4, '0']
- [blocks_selector_0_y, '0', virtual_sink_1, '0']
- [blocks_selector_1, '0', soapy_hackrf_sink_0, '0']
- [blocks_selector_2, '0', blocks_multiply_const_vxx_3_0, '0']
- [blocks_selector_3, '0', blocks_multiply_const_vxx_3, '0']
- [blocks_throttle_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_xx_0_0_0, '1']
- [blocks_uchar_to_float_0, '0', virtual_sink_0_1, '0']
- [epy_block_0_0, '0', blocks_repeat_0, '0']
- [epy_block_0_0, clear_input, qtgui_edit_box_msg_0, val]
- [epy_block_0_1, '0', blocks_repeat_0_0, '0']
- [epy_block_1, onair, blocks_message_debug_0, print]
- [epy_block_1, onair, blocks_msgpair_to_var_0, inpair]
- [epy_block_1_0, onair, blocks_message_debug_0, print]
- [epy_block_1_0, onair, blocks_msgpair_to_var_0_0, inpair]
- [epy_block_2, msgout, blocks_message_debug_1, print]
- [freq_xlating_fft_filter_ccc_1, '0', pfb_decimator_ccf_0_0, '0']
- [freq_xlating_fft_filter_ccc_1_0, '0', blocks_multiply_const_vxx_4_0_0_0, '0']
- [freq_xlating_fft_filter_ccc_1_0, '0', pfb_decimator_ccf_0_0_0, '0']
- [low_pass_filter_0, '0', blocks_float_to_complex_0_0_1, '1']
- [low_pass_filter_0_0, '0', blocks_float_to_complex_0_0_1, '0']
- [mmse_resampler_xx_0, '0', blocks_multiply_xx_0, '1']
- [mulc_lsb1, '0', blocks_float_to_complex_0_0_0, '0']
- [mulc_lsb_0, '0', blocks_float_to_complex_0_1, '0']
- [mulc_usb1, '0', blocks_float_to_complex_0_1_0_0, '0']
- [mulc_usb_0, '0', blocks_float_to_complex_0_1_0, '0']
- [pfb_decimator_ccf_0_0, '0', blocks_multiply_const_vxx_4_0, '0']
- [pfb_decimator_ccf_0_0_0, '0', blocks_multiply_const_vxx_4_0_0, '0']
- [pfb_decimator_ccf_0_1, '0', blocks_null_sink_3, '0']
- [pfb_decimator_ccf_0_1, '0', qtgui_freq_sink_x_0, '0']
- [qtgui_edit_box_msg_0, msg, epy_block_0_0, msg_in]
- [qtgui_edit_box_msg_1, msg, qtgui_sink_x_0, freq]
- [qtgui_edit_box_msg_1, msg, qtgui_waterfall_sink_x_0, freq]
- [qtgui_sink_x_0, freq, qtgui_edit_box_msg_1, val]
- [qtgui_waterfall_sink_x_0, freq, blocks_message_debug_0, print]
- [qtgui_waterfall_sink_x_0, freq, blocks_msgpair_to_var_2, inpair]
- [qtgui_waterfall_sink_x_0, freq, qtgui_edit_box_msg_1, val]
- [rational_resampler_xxx_0, '0', blocks_complex_to_real_0, '0']
- [rational_resampler_xxx_0_0_0, '0', blocks_complex_to_real_0_0_0, '0']
- [rational_resampler_xxx_1_0, '0', qtgui_time_sink_x_0, '1']
- [rational_resampler_xxx_4_0, '0', blocks_selector_1, '0']
- [rational_resampler_xxx_4_0, '0', blocks_selector_1, '1']
- [root_raised_cosine_filter_0, '0', root_raised_cosine_filter_0_0, '0']
- [root_raised_cosine_filter_0_0, '0', blocks_delay_0, '0']
- [root_raised_cosine_filter_0_0, '0', blocks_integrate_xx_1, '0']
- [root_raised_cosine_filter_0_0, '0', rational_resampler_xxx_1_0, '0']
- [rx_fq, valueout, blocks_msgpair_to_var_3, inpair]
- [soapy_hackrf_source_0, '0', freq_xlating_fft_filter_ccc_1, '0']
- [soapy_hackrf_source_0, '0', freq_xlating_fft_filter_ccc_1_0, '0']
- [virtual_source_0, '0', blocks_selector_2, '1']
- [virtual_source_0, '0', blocks_selector_3, '1']
- [virtual_source_0_1, '0', root_raised_cosine_filter_0, '0']
- [virtual_source_4, '0', blocks_selector_3, '0']
- [virtual_source_5, '0', blocks_selector_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
