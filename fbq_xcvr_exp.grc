options:
  parameters:
    author: Christer Bernérus, SM6FBQ
    category: Custom
    copyright: This design is free to use under GPL2
    description: VHF-UHF transceiver with CW, SSB, AM, FM and MGM connection
    generate_options: qt_gui
    id: FBQ_xcvr_2023
    output_language: python
    qt_qss_theme: /Users/bernerus/priv/proj/sdr/grc/FBQ_xcvr.qss
    realtime_scheduling: '1'
    title: SM6FBQ VHF/UHF transceiver
  states: {}

blocks:
- name: RX_power_offset_dB
  id: variable
  parameters:
    value: '-33'
  states: {}
- name: af_mix_matrices
  id: variable
  parameters:
    value: '[((1,0,0,0,0,0),(1,0,0,0,0,0)),  ((1,0,0,0,0,0),(1,0,0,0,0,0)),  ((0,1,0,0,0,0),(0,1,0,0,0,0)),  ((1,0,0,0,0,0),(1,0,0,0,0,0)),  ((1,0,0,0,0,0),(0,1,0,0,0,0)),  ((0,0,1,0,0,0),(0,0,0,1,0,0)),  ((0,0,0,0,1,0),(0,0,0,0,1,0)),  ((0,0,0,0,0,1),(0,0,0,0,0,1))]'
  states: {}
- name: af_right
  id: variable_qtgui_range
  parameters:
    gui_hint: settings_tab@0:10, 1, 1, 2
    label: AF BAL
    min_len: '100'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
    widget: slider
  states: {}
- name: agc_attack
  id: variable_qtgui_range
  parameters:
    gui_hint: settings_tab@3:12, 1, 1, 2
    label: AGC attack
    min_len: '100'
    start: '0.0'
    step: '0.01'
    stop: '3'
    value: '0.01'
  states: {}
- name: agc_decay
  id: variable_qtgui_range
  parameters:
    gui_hint: settings_tab@3:13, 1, 1, 2
    label: AGC decay
    min_len: '100'
    start: '0'
    step: '3e-7'
    stop: '50e-7'
    value: '8e-7'
  states: {}
- name: am_chain_gain
  id: variable
  parameters:
    value: 0,0,0,0,0,0,0,1
  states: {}
- name: audio_samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: band_selector
  id: variable_qtgui_chooser
  parameters:
    comment: Selects the frequency band to use
    gui_hint: 1,3,1,2
    label: BAND
    labels: ham_bands_keys
    num_opts: '0'
    options: ham_bands_keys
    orient: Qt.QHBoxLayout
    type: string
    value: '''                  '''
  states: {}
- name: bpf_high
  id: variable
  parameters:
    value: 5000,4000,3300,2800,1530,1130,1080, 905
  states: {}
- name: bpf_low
  id: variable
  parameters:
    value: 100, 100,100,100,230,630,780, 855
  states: {}
- name: channel_separation
  id: variable
  parameters:
    value: '[100,100,10,10,1000,1000]'
  states: {}
- name: cq_flavor
  id: variable_qtgui_chooser
  parameters:
    label: CQ Flavor
    label0: None
    label1: Aurora
    label2: Test
    label3: Dx
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: cq_flavors
  id: variable
  parameters:
    value: '[('''','''','''',''+''),(''A'',''A'',''A'',''A''),(''TEST'',''TEST'',''TES'',''+''),(''DX'',''DX'',''DX'',''DX'')]'
  states: {}
- name: current_allowed_modes
  id: variable_qtgui_entry
  parameters:
    comment: Displays a list od the allowed transmission modes in the selected band
    gui_hint: settings_tab@2:0,5,1,1
    label: Modes
    type: raw
    value: ham_bands[band_selector][4]
  states: {}
- name: current_allowed_tx_bandwidth
  id: variable_qtgui_entry
  parameters:
    comment: Displays the allowed transmitter bandwidth of the selected band
    gui_hint: settings_tab@2:0,4,1,1
    label: Bw
    type: real
    value: ham_bands[band_selector][3]
  states: {}
- name: current_default_fq
  id: variable_qtgui_entry
  parameters:
    comment: Displays the default frequency of the selected band
    gui_hint: settings_tab@2:0,2,1,1
    label: Def-fq
    type: real
    value: ham_bands[band_selector][2]
  states: {}
- name: current_max_fq
  id: variable_qtgui_entry
  parameters:
    comment: Displays the highest frequency of the selected band
    gui_hint: settings_tab@2:0,1,1,1
    label: Max-fq
    type: real
    value: ham_bands[band_selector][1]
  states: {}
- name: current_min_fq
  id: variable_qtgui_entry
  parameters:
    comment: Displays the lowest frequency of the selected band
    gui_hint: settings_tab@2:0,0,1,1
    label: Min-fq
    type: real
    value: ham_bands[band_selector][0]
  states: {}
- name: current_op_tab
  id: variable_qtgui_entry
  parameters:
    comment: Displays the rx filter frequency
    gui_hint: settings_tab@2:5,1,1,1
    label: Op tab
    type: string
    value: op_tab.currentIndex
  states: {}
- name: cw_level
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: op_tab@2:0,0,1,1
    label: CW TX LEVEL
    maximum: '95'
    minimum: '0'
    minsize: '50'
    relBackgroundColor: lime
    scaleFactor: '0.01'
    showvalue: 'True'
    type: real
    value: '0.8'
  states: {}
- name: cw_midear_beat
  id: variable
  parameters:
    value: 0,0,0,880,880,0,0,0
  states: {}
- name: cw_mon_delay
  id: variable_qtgui_entry
  parameters:
    gui_hint: op_tab@2:1,5,1,1
    label: CW mnitor delay
    type: int
    value: '3'
  states: {}
- name: cw_samp_rate
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: cw_txing
  id: variable
  parameters:
    value: '0'
  states: {}
- name: cw_vox_attack
  id: variable_qtgui_entry
  parameters:
    gui_hint: op_tab@2:1,3,1,1
    label: CW vox attack
    type: real
    value: '0.4'
  states: {}
- name: cw_vox_delay
  id: variable_qtgui_entry
  parameters:
    gui_hint: op_tab@2:1,4,1,1
    label: CW vox delay
    type: real
    value: '3.5'
  states: {}
- name: cw_vox_threshold
  id: variable_qtgui_entry
  parameters:
    gui_hint: op_tab@2:1,2,1,1
    label: CW vox threshold
    type: real
    value: '0.4'
  states: {}
- name: debug_desired_fft_bw
  id: variable_qtgui_entry
  parameters:
    comment: Displays the rx frequency of the hackrf
    gui_hint: settings_tab@2:4,0,1,1
    label: Desired fft bndwidth
    type: real
    value: fft_bw_desired
  states: {}
- name: debug_fft_decim
  id: variable_qtgui_entry
  parameters:
    comment: Displays the rx frequency of the hackrf
    gui_hint: settings_tab@2:5,0,1,1
    label: FFT decimation value
    type: real
    value: fft_decim
  states: {}
- name: debug_side_band_rx
  id: variable_qtgui_entry
  parameters:
    comment: Displays the rx frequency of the hackrf
    gui_hint: settings_tab@2:5,2,1,1
    label: Side_band_rx
    type: real
    value: side_band_rx
  states: {}
- name: dx_call
  id: variable_qtgui_entry
  parameters:
    gui_hint: op_tab@2:3,0,1,1
    label: DX call
    type: string
    value: ''
  states: {}
- name: f0
  id: variable
  parameters:
    value: current_min_fq + (current_max_fq - current_min_fq)/2.0
  states: {}
- name: f0_min
  id: variable
  parameters:
    value: ham_bands[band_selector][0]
  states: {}
- name: fft_bw_desired
  id: variable
  parameters:
    value: min(if0_samp_rate, 100+abs(current_max_fq-current_min_fq))
  states: {}
- name: fft_center_fq
  id: variable
  parameters:
    value: rx_hw_fq + filter_fq + fft_corr[side_band_rx]
  states: {}
- name: fft_corr
  id: variable
  parameters:
    value: 0,0,0,880,0,0,0,0
  states: {}
- name: fft_decim
  id: variable
  parameters:
    value: rx_samp_rate/fft_bw_desired
  states: {}
- name: filter_fq
  id: variable
  parameters:
    comment: Demodulator offset of hardware receiver.
    value: '0'
  states: {}
- name: fm_gain
  id: variable
  parameters:
    value: '1.2'
  states: {}
- name: fq_calibration
  id: variable_qtgui_range
  parameters:
    gui_hint: settings_tab@0:11, 1, 1, 2
    label: FQ CAL
    min_len: '100'
    start: '-50'
    step: '1'
    stop: '50'
    value: '26'
  states: {}
- name: freq
  id: variable
  parameters:
    comment: From the waterfall. Bad name but hard to change it seems-
    value: '0'
  states: {}
- name: ham_bands
  id: variable
  parameters:
    comment: |-
      Dummy variable to satisfy GRC checks. The band_plan code snippet will 
      replace its value on startup.
    value: '{''                  '':(30e6,6e9,0,0,[''CW''])}'
  states: {}
- name: ham_bands_keys
  id: variable
  parameters:
    comment: |-
      Dummy variable to satisfy GRC checks. The band_plan code snippet will 
      replace its value on startup.
    value: '[''                  '']'
  states: {}
- name: if0_samp_rate
  id: variable
  parameters:
    value: rx_samp_rate
  states: {}
- name: if2_samp_rate
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: if_samp_rate
  id: variable
  parameters:
    value: 1000e3
  states: {}
- name: lna_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: settings_tab@0:5, 1, 1, 1
    label: RX LNA GAIN
    min_len: '100'
    start: '0'
    step: '1'
    stop: '39'
    value: '39'
    widget: dial
  states: {}
- name: loop_bw_hz
  id: variable
  parameters:
    value: '300'
  states: {}
- name: loop_bw_rad
  id: variable
  parameters:
    value: loop_bw_hz*2*3.14159265359/audio_samp_rate
  states: {}
- name: loop_fq_trk_hz
  id: variable
  parameters:
    value: '300'
  states: {}
- name: loop_fq_trk_rad
  id: variable
  parameters:
    value: loop_fq_trk_hz * 2 * pi / audio_samp_rate
  states: {}
- name: lsb_chain_gain
  id: variable
  parameters:
    value: 0,0,1,0,1,0,0,0
  states: {}
- name: mgm_inpt_gain
  id: variable_qtgui_entry
  parameters:
    comment: Displays thecurrent MGM imput gain
    gui_hint: settings_tab@2:3,0,1,1
    label: MGM input gain
    type: real
    value: mgm_input_gain
  states: {}
- name: mgm_input_gain
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: op_tab@1:0,0,1,1
    label: MGM INPUT GAIN
    maximum: '1995'
    minimum: '0'
    minsize: '50'
    relBackgroundColor: silver
    scaleFactor: '0.001'
    showvalue: 'True'
    type: real
    value: '1.4'
  states: {}
- name: mgm_output_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: op_tab@1:0, 1, 1, 1
    label: ' MGM VOL'
    min_len: '50'
    start: '0'
    step: '0.1'
    stop: '20'
    value: '2'
    widget: dial
  states: {}
- name: mic_gain
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: op_tab@0:3,6,1,1
    label: MIC GAIN
    maximum: '995'
    minimum: '0'
    minsize: '50'
    relBackgroundColor: silver
    scaleFactor: '0.001'
    showvalue: 'True'
    type: real
    value: '0.2'
  states: {}
- name: mic_inpt_gain_0
  id: variable_qtgui_entry
  parameters:
    comment: Displays thecurrent MGM imput gain
    gui_hint: settings_tab@2:3,1,1,1
    label: MIC gain
    type: real
    value: mic_gain
  states: {}
- name: mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3, 3, 1, 1
    label: TX MODE
    labels: mode_labels_keys
    num_opts: '0'
    options: mode_labels_values
    type: int
    value: mode_default_option
    widget: radio_buttons
  states: {}
- name: mode_default_option
  id: variable
  parameters:
    value: mode_labels[[l for l in current_allowed_modes if l in mode_labels][0]]
  states: {}
- name: mode_display
  id: variable_qtgui_entry
  parameters:
    comment: Displays the rx frequency of the hackrf
    gui_hint: settings_tab@2:2,1,1,1
    label: Mode
    type: int
    value: mode
  states: {}
- name: mode_labels
  id: variable
  parameters:
    value: '{''None'':0 , ''USB'':1, ''LSB'':2, ''CW'': 3, ''CW Stereo'':4, ''MGM'':5, ''WBFM'':6,''NBFM'':7, ''AM'':8}'
  states: {}
- name: mode_labels_keys
  id: variable
  parameters:
    value: list(mode_labels.keys())
  states: {}
- name: mode_labels_values
  id: variable
  parameters:
    value: list(mode_labels.values())
  states: {}
- name: mode_options
  id: variable
  parameters:
    value: '[0, 1, 2, 3, 4, 5,6]'
  states: {}
- name: mode_to_audio_input
  id: variable
  parameters:
    value: '[0,2,2,0,0,1,0,2,0]'
  states: {}
- name: mode_to_sb_rx
  id: variable
  parameters:
    value: '[3,1,2,3,4,1,5,6,7]'
  states: {}
- name: mode_to_sb_tx
  id: variable
  parameters:
    value: '[0,1,1,3,3,1,0,2,0]'
  states: {}
- name: monitor
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: op_tab@2:0,2,1,1
    label: CW feedback
    maximum: '100'
    minimum: '0'
    relBackgroundColor: teal
    showvalue: 'True'
    type: real
    value: '25'
  states: {}
- name: morse_speed
  id: variable_qtgui_dial_control
  parameters:
    comment: Morse speed in characters per minute, not WPM
    gui_hint: op_tab@2:0,1,1,1
    label: MORSE SPEED [CPM]
    maximum: '200'
    minimum: '40'
    minsize: '50'
    relBackgroundColor: navy
    showvalue: 'True'
    type: real
    value: '120'
  states: {}
- name: nbfm_chain_gain
  id: variable
  parameters:
    value: 0,0,0,0,0,0,1,0
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.14159265358979323846264338327950288419716939937511'
  states: {}
- name: qtgui_levelgauge_0
  id: qtgui_levelgauge
  parameters:
    backgroundColor: silver
    barColor: orange
    fontColor: teal
    gui_hint: 3,0,1,2
    isVertical: 'False'
    label: S-meter [dBm]
    maximum: '30'
    minimum: '-30'
    msize: '50'
    showValue: 'True'
    type: real
    value: variable_function_probe_0
  states: {}
- name: rf_mix_matrices
  id: variable
  parameters:
    value: '[((0,0,0),),  ((1,0,0),),  ((0,1,0),),  ((0,0,1),)]'
  states: {}
- name: rx_bw
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3, 2, 1, 1
    label: RX BW - kHz
    labels: '[''5'',''3.9'',''3.2'',''2.7'',''1.3'',''0.5'',''0.2'',''0.05'']'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5, 6,7]'
    type: int
    value: '2'
    widget: radio_buttons
  states: {}
- name: rx_center_fq
  id: variable
  parameters:
    value: f0-100e3
  states: {}
- name: rx_ctr_fq
  id: variable_qtgui_entry
  parameters:
    comment: Displays the rx frequency of the hackrf
    gui_hint: settings_tab@2:1,0,1,1
    label: Rx center fq
    type: int
    value: int(rx_hw_fq)
  states: {}
- name: rx_ctr_fq_0
  id: variable_qtgui_entry
  parameters:
    comment: Displays the rx filter frequency
    gui_hint: settings_tab@2:1,1,1,1
    label: Rx filter fq
    type: int
    value: int(filter_fq)
  states: {}
- name: rx_fq
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rx_fq_win
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    ThousandsSeparator: '.'
    comment: Receiver zero beat frequency
    gui_hint: 2,2,1,1
    lbl: RX FQ
    maxFreqHz: current_max_fq
    minFreqHz: current_min_fq - 29e6
    relFontColor: green
    value: current_default_fq
  states: {}
- name: rx_hw_fq
  id: variable
  parameters:
    comment: Center frequency of hardware receiver
    value: '0'
  states: {}
- name: rx_preamp
  id: variable_qtgui_chooser
  parameters:
    gui_hint: settings_tab@0:4,1,1,1
    label: RX Preamp
    label0: 'OFF'
    label1: 'ON'
    labels: '[''Barefoot'',''PA'']'
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: rx_samp_rate
  id: variable_qtgui_chooser
  parameters:
    labels: '[''1 MHz'',''2 MHz'',''3 MHz'',''4 MHz'',''5 MHz'',''6 MHz'',''7 MHz'',''8 MHz'']'
    num_opts: '0'
    options: '[1000000, 2000000,3000000,4000000,5000000,6000000,7000000,8000000]'
    orient: Qt.QHBoxLayout
    type: int
    value: '3000000'
    widget: radio_buttons
  states: {}
- name: sb_r
  id: variable
  parameters:
    value: '[-1,1,1,-1]'
  states: {}
- name: sb_t
  id: variable
  parameters:
    value: '[1,-1,1,1]'
  states: {}
- name: side_band_dislay
  id: variable_qtgui_entry
  parameters:
    comment: Displays the rx frequency of the hackrf
    gui_hint: settings_tab@2:2,2,1,1
    label: Side-band
    type: int
    value: side_band_rx
  states: {}
- name: side_band_rx
  id: variable
  parameters:
    value: mode_to_sb_rx[mode]
  states: {}
- name: side_band_tx
  id: variable
  parameters:
    value: mode_to_sb_tx[mode]
  states: {}
- name: spkr_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 0, 1, 1
    label: '  AF VOL'
    min_len: '50'
    start: '0'
    step: '1'
    stop: '200'
    value: '35'
    widget: dial
  states: {}
- name: split_fq
  id: variable_qtgui_check_box
  parameters:
    comment: Checkbox to enable split frequencies
    'false': 'True'
    gui_hint: 2,3,1,1
    label: Split freq
    'true': 'False'
    type: bool
    value: 'True'
  states: {}
- name: sq
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: SQUELCH
    min_len: '50'
    start: '-110'
    step: '1'
    stop: '0'
    value: '-110'
    widget: dial
  states: {}
- name: ssb_tx_bandwidth
  id: variable
  parameters:
    value: tx_bw[tx_bw_opts]
  states: {}
- name: ssb_txing
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ssb_txing_btn
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 2,5,1,1
    label: PTT
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: morse_speed*8.33/50
  states: {}
- name: tc_vga
  id: variable_qtgui_entry
  parameters:
    comment: Displays the rx frequency of the hackrf
    gui_hint: settings_tab@2:2,3,1,1
    label: TX VGA
    type: real
    value: tx_gain
  states: {}
- name: tx_bw
  id: variable
  parameters:
    value: '[5000.0,3500.0,2500.0,1750.0,500.0]'
  states: {}
- name: tx_bw_opts
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3, 4, 1, 1
    label: TX BW - kHz
    label0: '5'
    label1: '3.5'
    label2: '2.5'
    label3: '1.75'
    label4: '0.5'
    labels: '[''3.9'',''2.7'',''0.5'',''0.2'']'
    num_opts: '5'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    option4: '4'
    type: int
    value: '1'
    widget: radio_buttons
  states: {}
- name: tx_center_fq
  id: variable
  parameters:
    value: current_default_fq
  states: {}
- name: tx_fq
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tx_fq_q
  id: variable_qtgui_entry
  parameters:
    comment: Displays the rx frequency of the hackrf
    gui_hint: settings_tab@2:2,0,1,1
    label: TX fq
    type: int
    value: int(tx_fq)
  states: {}
- name: tx_fq_win
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    ThousandsSeparator: '.'
    gui_hint: 2,4,1,1
    lbl: TX FQ
    maxFreqHz: current_max_fq - current_allowed_tx_bandwidth
    minFreqHz: current_min_fq + current_allowed_tx_bandwidth - 29e6
    readOnly: (not split_fq)
    relFontColor: red
    value: tx_center_fq
  states: {}
- name: tx_gain
  id: variable_qtgui_dial_control
  parameters:
    comment: HackRF transmit gain [dB]
    gui_hint: settings_tab@1:3,5,1,1
    label: TX GAIN
    maximum: '47'
    minimum: '1'
    minsize: '50'
    relBackgroundColor: orange
    showvalue: 'True'
    type: int
    value: '47'
  states: {}
- name: tx_mode_offset
  id: variable
  parameters:
    value: '[0, tx_bw[tx_bw_opts]/2, -tx_bw[tx_bw_opts]/2, 0, 0, tx_bw[tx_bw_opts]/2,tx_bw[tx_bw_opts]/2]'
  states: {}
- name: tx_rprt
  id: variable_qtgui_entry
  parameters:
    gui_hint: op_tab@2:3,1,1,1
    label: TX report
    type: string
    value: ''
  states: {}
- name: tx_samp_rate
  id: variable
  parameters:
    value: '8000000'
  states: {}
- name: tx_samp_rate_out
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: txing
  id: variable
  parameters:
    value: cw_txing or ssb_txing
  states: {}
- name: usb_chain_gain
  id: variable
  parameters:
    value: 1,1,0,1,1,0,0,0
  states: {}
- name: variable_function_probe_0
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_0
    function_name: level
    poll_rate: '20'
    value: '0'
  states: {}
- name: variable_qtgui_chooser_0
  id: variable_qtgui_chooser
  parameters:
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: '0'
  states: {}
- name: variable_qtgui_entry_0
  id: variable_qtgui_entry
  parameters:
    label: Selector
    type: int
    value: side_band_rx
  states: {}
- name: vga_gain
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: settings_tab@0:5,2,1,1
    label: RX VGA Gain
    maximum: '61'
    minimum: '0'
    minsize: '50'
    relBackgroundColor: teal
    showvalue: 'True'
    type: int
    value: '61'
  states: {}
- name: vox_attack
  id: variable
  parameters:
    value: '[10000,10,10,1,1,1,1,1,1]'
  states: {}
- name: vox_delay
  id: variable
  parameters:
    value: '[0,1.5,1.5,0.7,0.7,0.5,0.5,1.5,0]'
  states: {}
- name: vox_sensitivity
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: op_tab@0:4,6,1,1
    label: VOX SENS
    maximum: '200'
    minimum: '0'
    minsize: '50'
    relBackgroundColor: teal
    showvalue: 'True'
    type: int
    value: '20'
  states: {}
- name: vox_threshold
  id: variable
  parameters:
    value: '[10000,0.6,0.6,0.4,0.4,0.4,10000,0.6, 10000]'
  states: {}
- name: wbfm_chain_gain
  id: variable
  parameters:
    value: 0,0,0,0,0,1,0,0
  states: {}
- name: wbfm_if2_samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: wf_fq
  id: variable
  parameters:
    value: freq+rx_hw_fq
  states: {}
- name: wf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 8,2,1,1
    label: Waterfall gain
    min_len: '100'
    start: '0'
    step: '1'
    stop: '100'
    value: '75'
    widget: dial
  states: {}
- name: after_start
  id: snippet
  parameters:
    code: |-
      import appnope
      appnope.nope()

      self._band_selector_combo_box.removeItem(0)
      for _label in self._band_selector_labels: self._band_selector_combo_box.addItem(_label)
      self._band_selector_callback = lambda i: Qt.QMetaObject.invokeMethod(self._band_selector_combo_box, "setCurrentIndex", Qt.Q_ARG("int", self._band_selector_options.index(i)))
      self._band_selector_combo_box.currentIndexChanged.connect(
          lambda i: self.set_band_selector(self._band_selector_options[i])
      )


      self._band_selector_combo_box.setCurrentIndex(22)
      self.rx_distancer.desired_fq=self.ham_bands['144-FT8'][2]
    priority: '1'
    section: main_after_start
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '5'
    reference: '0.5'
    type: float
  states: {}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1'
    decay_rate: '3e-6'
    gain: '.8'
    iir_update_decim: '1'
    max_gain: '1.0'
    reference: (.001)*0+.002 + 0.8
    type: complex
  states: {}
- name: analog_agc3_xx_0_0
  id: analog_agc3_xx
  parameters:
    attack_rate: agc_attack
    decay_rate: agc_decay
    gain: '0.8'
    iir_update_decim: '1'
    max_gain: '1.0'
    reference: (.001)*0+.002 + 0.8
    type: complex
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '5000'
    audio_stop: '8000'
    chan_rate: audio_samp_rate
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: int(audio_samp_rate)
    max_dev: 5e3
    quad_rate: int(wbfm_if2_samp_rate/int(wbfm_if2_samp_rate/10000)*int(audio_samp_rate/1000))
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_samp_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: audio_samp_rate*4
    tau: '75e-6'
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: '-loop_fq_trk_rad'
    min_freq: loop_fq_trk_rad
    w: loop_bw_rad if pi/200 < loop_bw_rad < 2*pi/100 else None
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: cw_midear_beat[side_band_tx]
    offset: '0'
    phase: '0'
    samp_rate: cw_samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: ssb_tx_bandwidth/2
    offset: '0'
    phase: '0'
    samp_rate: audio_samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '127'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: tx_samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_1_0
  id: analog_sig_source_x
  parameters:
    amp: '-1 if mode==2 else 1'
    freq: ssb_tx_bandwidth/2
    offset: '0'
    phase: '0'
    samp_rate: audio_samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '.001'
    threshold: sq
  states: {}
- name: analog_simple_squelch_cc_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '.001'
    threshold: sq
  states: {}
- name: analog_simple_squelch_cc_0_1
  id: analog_simple_squelch_cc
  parameters:
    alpha: '.001'
    threshold: sq
  states: {}
- name: analog_simple_squelch_cc_0_1_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '.001'
    threshold: sq
  states: {}
- name: analog_wfm_rcv_pll_0
  id: analog_wfm_rcv_pll
  parameters:
    audio_decimation: '10'
    deemph_tau: '75e-6'
    quad_rate: wbfm_if2_samp_rate/int(wbfm_if2_samp_rate/10000)*int(audio_samp_rate/1000)
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    device_name: '"std_spkr"'
    samp_rate: audio_samp_rate
  states: {}
- name: audio_sink_0_1
  id: audio_sink
  parameters:
    device_name: '"std_spkr"'
    num_inputs: '2'
    samp_rate: audio_samp_rate
  states: {}
- name: audio_sink_0_2
  id: audio_sink
  parameters:
    device_name: '"WSJT-3"'
    num_inputs: '2'
    samp_rate: audio_samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    comment: MGM audio input. E.g. from WSJT-X
    device_name: '"BlackHole 16ch"'
    samp_rate: audio_samp_rate
  states: {}
- name: audio_source_0_0
  id: audio_source
  parameters:
    comment: Microphone audio input.
    device_name: '"MacBook Pro-mikrofon"'
    samp_rate: audio_samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    comment: |-
      The SSB modulator comprises the first half of a Weaver modulator. 
      The audio is mixed in two chains with a carrier that is 90° out of 
      phase in the two chains. The carrier frequency is in the middle of the 
      transmitter bandwidth. The first filter limits the input audio bandwidth. 
      After mixing, anoter filter limits the resulting signal in each chain to 
      half of the bandwidth. The two chanis are then combined to a complex signal
      and the second half of the Weaver modulator is done within the SDR hardware.
    decim: '1'
    gain: '1'
    high_cutoff_freq: '2700'
    low_cutoff_freq: '200'
    samp_rate: audio_samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: int(if_samp_rate/if2_samp_rate)
    gain: '1'
    high_cutoff_freq: bpf_high[rx_bw]
    low_cutoff_freq: bpf_low[rx_bw]
    samp_rate: if_samp_rate
    type: fir_filter_ccc
    width: '100'
    win: window.WIN_BLACKMAN
  states: {}
- name: band_pass_filter_0_1
  id: band_pass_filter
  parameters:
    decim: int(if_samp_rate/if2_samp_rate)
    gain: '1'
    high_cutoff_freq: bpf_high[rx_bw]
    low_cutoff_freq: bpf_low[rx_bw]
    samp_rate: if_samp_rate
    type: fir_filter_ccc
    width: '100'
    win: window.WIN_BLACKMAN
  states: {}
- name: band_pass_filter_0_2
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '4000'
    low_cutoff_freq: '200'
    samp_rate: audio_samp_rate
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: band_plan
  id: snippet
  parameters:
    code: |-
      self.ham_bands = {
                  '50-CW':    (50000000,   50100000,   50090000,    500, ['CW']),
              '50-SSB':   (50100000,   50300000,   50150000,   2700, ['CW', 'USB','LSB']),
              '50-FT8':   (50300000,   50400000,   50313000,   2700, ['MGM','FT8','USB']),
              '50-PSK':   (50300000,   50400000,   50305000,   2700, ['MGM','PSK','USB']),
              '50-MSK':   (50300000,   50400000,   50350000,   2700, ['MGM','MSK','USB']),
              '50-B':     (50400000,   50500000,   50450000,   1000, ['None']),  # Beacons only
              '50-FM':    (50500000,   52000000,   51510000,  12000, ['FM', 'CW', 'SSB']),
              '87-WBFM':    (87500000,  108000000,   89300000, 200000, ['WBFM']),  # FM broadcast
              'LAV-VOR': (108000000,   137000000,  114600000,   4000,['AM']), # Air traffic
              'LAV-ATIS': (108000000,   137000000,  118375000,   4000,['AM']), # Air traffic
              'LAV-Ground-1': (108000000,   137000000,  121600000,   4000,['AM']), # Air traffic
              'LAV-Ground-2': (108000000,   137000000,  121900000,   4000,['AM']), # Air traffic
              'LAV-Tower-1': (108000000,   137000000,  118600000,   4000,['AM']), # Air traffic
              'LAV-Tower-2': (108000000,   137000000,  123100000,   4000,['AM']), # Air traffic
              'LAV-Approach-2': (108000000,   137000000,  123300000,   4000,['AM']), # Air traffic
              'LAV-Approach-3': (108000000,   137000000,  124200000,   4000,['AM']), # Air traffic
              'LAV-Approach-4': (108000000,   137000000,  124675000,   4000,['AM']), # Air traffic
              '144-SAT':  (144000000, 144025000,  144010000,   2700, ['None']),  # Sat downlink,
              '144-CW':   (144025000, 144100000,  144050000,    500, ['CW']),
              '144-MGM':  (144100000, 144150000,  144116000,    500, ['CW', 'Q65', 'JT65'],'USB'),
              '144-Q65':  (144100000, 144150000,  144125000,    500, ['MGM','Q65','USB']),
              '144-JT65': (144100000, 144150000,  144120000,    500, ['MGM','JT65','USB']),
              '144-FT8':  (144150000, 144400000,  144174000,   2700, ['MGM','USB']),
              '144-SSB':  (144150000, 144400000,  144300000,   2700, ['USB', 'CW', 'FT8', 'JT65', 'Q65','LSB']),
              '144-MSK':  (144150000, 144400000,  144360000,   2700, ['MGM','MSK','USB']),
              '144-SK6VHF':    (144400000, 144490000,  144406029,    500, ['CW']),  # Beacon SK6VHF
              '144-SK4MPI':    (144400000, 144490000,  144412000,    500, ['CW']),  # Beacon SK4MPI
              '144-SK1VHF':    (144400000, 144490000,  144447000,    500, ['CW']),  # Beacon SK1VHF
              '144-LA8VHF':    (144400000, 144490000,  144480000,    500, ['CW']),  # Beacon LA8VHF
              '144-OZ7IGY':    (144400000, 144490000,  144471000,    500, ['CW']),  # Beacon OZ7IGY
              '144-GB3VHF':    (144400000, 144490000,  144430000,    500, ['CW']),  # Beacon GB3VHF
              '144-PB':   (144491000, 144493000,  144492000,    500, ['CW', 'FT8']),  # Personal beacons
              '432-EME':  (432000000, 432025000,  432010000,    500, ['CW']),
              '432-CW':   (432025000, 432100000,  432050000,    500, ['CW','PSK']),
              '432-FT8':  (432150000, 432400000,  432174000,   2700, ['MGM','FT8','USB']),
              '432-SSB':  (432100000, 432400000,  432200000,   2700, ['CW', 'USB']),
              '432-FSK':  (432100000, 432400000,  432370000,   2700, ['CW', 'USB', 'FSK441','LSB']),
              '432-B':    (432400000, 432490000,  432412170,    500, ['CW']), # Beacons 70cm / SK6UHF
              '1296-B':  (1296800000, 1296994000,1296811000,    500, ['CW']), # Beacons 23cm


      }
      self.ham_bands_keys = list(self.ham_bands)
      self._band_selector_options = self.ham_bands_keys
      self._band_selector_labels = self.ham_bands_keys

      self._band_selector_combo_box.setMinimumContentsLength(10)

      def find_valid_mode(self, valid_modes):
      	available_modes = self.mode.labels
      	print(available_modes)
      	print(valid_modes)

      	for mode in valid_modes:
      		if mode in available_modes:
      			return available_modes.index(mode) 
      	return 0
    comment: |-
      This python snippet defines which frequency bands the transceiver supports.
      Each band has a designator, a min and max frequency, a default frequency and a list of
      allowed transmission modes.
    section: main_after_init
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: complex
  states: {}
- name: blocks_complex_to_float_0_1_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_2
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_2_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_2_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_2_0_1
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: cw_mon_delay
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/hackrf_samples
    type: complex
  states: {state: disabled}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: 1 if mode > 0 else 0
  states: {}
- name: blocks_float_to_complex_0_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_1_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_1_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_3
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_3_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_int_0
  id: blocks_float_to_int
  parameters:
    scale: '1'
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: if2_samp_rate
    type: float
  states: {}
- name: blocks_integrate_xx_1
  id: blocks_integrate_xx
  parameters:
    decim: '50'
    type: float
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: int(fft_decim)
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: int(wbfm_if2_samp_rate/if2_samp_rate)
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0_1
  id: blocks_keep_one_in_n
  parameters:
    n: int(wbfm_if2_samp_rate/if2_samp_rate)
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: cw_txing
  states: {}
- name: blocks_msgpair_to_var_0_0
  id: blocks_msgpair_to_var
  parameters:
    target: ssb_txing
  states: {}
- name: blocks_msgpair_to_var_1
  id: blocks_msgpair_to_var
  parameters:
    target: rx_fq
  states: {}
- name: blocks_msgpair_to_var_1_0
  id: blocks_msgpair_to_var
  parameters:
    target: rx_hw_fq
  states: {}
- name: blocks_msgpair_to_var_1_0_0
  id: blocks_msgpair_to_var
  parameters:
    target: filter_fq
  states: {}
- name: blocks_msgpair_to_var_1_1
  id: blocks_msgpair_to_var
  parameters:
    target: tx_fq
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: monitor*0.0001*1000
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: cw_level*0.8
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 0.01*spkr_gain *af_right
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: mgm_output_gain *af_right
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: mgm_input_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: mic_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: vox_sensitivity/20
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 0.004*spkr_gain*(1-af_right)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_1_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: mgm_output_gain*(1-af_right)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_1_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: fm_gain*0.4
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_1_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: fm_gain*0.4
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_1_0_1_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: fm_gain*0.2
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_1_0_1_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: fm_gain*6
    type: float
  states: {}
- name: blocks_multiply_const_vxx_4_0
  id: blocks_multiply_const_vxx
  parameters:
    const: lsb_chain_gain[side_band_rx]
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_4_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: usb_chain_gain[side_band_rx]
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_4_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: wbfm_chain_gain[side_band_rx]
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_4_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: nbfm_chain_gain[side_band_rx]
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_4_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: am_chain_gain[side_band_rx]
    type: complex
  states: {}
- name: blocks_multiply_matrix_xx_0
  id: blocks_multiply_matrix_xx
  parameters:
    A: af_mix_matrices[side_band_rx]
    comment: |-
      Instead of using a selector here, 
      the multiply by matrix does the 
      same thing, but does not introduce 
      different delays for the different chains
      causing stereo signals go out of sync.
    tag_propagation_policy: gr.TPP_DONT
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: RX_power_offset_dB
    n: '10.6'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_2_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_2_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_1
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_probe_signal_x_0
  id: blocks_probe_signal_x
  parameters:
    comment: S-meter
    type: int
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(cw_samp_rate/symbol_rate)
    type: byte
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    comment: output samp rate = 3 MHz
    interp: int(tx_samp_rate/cw_samp_rate)
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    comment: |-
      The SSB signal selector either sends the output to the SDR output 
      or to a Null sink depending on the current mode. There is no way to actually
      turn the path off.
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: (ssb_txing or ssb_txing_btn) and 0 < mode < 6
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    comment: |-
      The FM signal selector either sends the output to the SDR output 
      or to a Null sink depending on the current mode. There is no way to actually
      turn the path off.
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: (ssb_txing or ssb_txing_btn) and side_band_tx == 2
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    comment: |-
      The RF signal selector selecte between a SSB signal, a CW signal or None, 
      depending on mode.
    enabled: 'True'
    input_index: max(side_band_tx -1, 0)
    num_inputs: '3'
    num_outputs: '2'
    output_index: 1 if  (ssb_txing or ssb_txing_btn) and side_band_tx or cw_txing else 0
    type: complex
  states: {}
- name: blocks_selector_2
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: mode_to_audio_input[mode]
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: clear_cw_msg
  id: virtual_sink
  parameters:
    stream_id: clear_cw_msg
  states: {}
- name: cq_msg_in
  id: virtual_sink
  parameters:
    stream_id: cw_stream
  states: {}
- name: cw_msg_in
  id: virtual_source
  parameters:
    stream_id: cw_stream
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Morse code vector source
      """

      #  epy_block_0.py
      #  revised 09/10/2019 - finish code table
      #  revised 09/11/2019 - test for bad character
      #  revised 09/27/2019 - get input from a Message Edit block (code from Volker Schroer dl1ksv)

      import numpy as np
      from gnuradio import gr

      import pmt

      textboxValue = ""

      Morse = {
          # codes from https://www.itu.int/rec/R-REC-M.1677-1-200910-I/en
          "A": "10111",
          "B": "111010101",
          "C": "11101011101",
          "D": "1110101",
          "E": "1",
          "F": "101011101",
          "G": "111011101",
          "H": "1010101",
          "I": "101",
          "J": "1011101110111",
          "K": "111010111",
          "L": "101110101",
          "M": "1110111",
          "N": "11101",
          "O": "11101110111",
          "P": "10111011101",
          "Q": "1110111010111",
          "R": "1011101",
          "S": "10101",
          "T": "111",
          "U": "1010111",
          "V": "101010111",
          "W": "101110111",
          "X": "11101010111",
          "Y": "1110101110111",
          "Z": "11101110101",
          "Å": "101110111010111",
          "Ä": "10111010111",
          "Ö": "1110111011101",
          " ": "0",
          "1": "10111011101110111",
          "2": "101011101110111",
          "3": "1010101110111",
          "4": "10101010111",
          "5": "101010101",
          "6": "11101010101",
          "7": "1110111010101",
          "8": "111011101110101",
          "9": "11101110111011101",
          "0": "1110111011101110111",
          ".": "10111010111010111",  # period
          ",": "1110111010101110111",  # comma
          ":": "11101110111010101",  # colon
          "?": "101011101110101",  # question
          "'": "1011101110111011101",  # apostrophe
          "-": "111010101010111",  # dash or minus
          "/": "1110101011101",  # slash
          "(": "111010111011101",  # left parenthesis
          ")": "1110101110111010111",  # right parenthesis
          "\"": "101110101011101",  # quote
          "=": "1110101010111",  # equals
          "+": "1011101011101",  # plus
          "@": "10111011101011101",  # at sign (@)
          # these punctuation marks are not included in the ITU recommendation
          # but are found in https://en.wikipedia.org/wiki/Morse_code
          "!": "1110101110101110111",  # exclamation point
          "&": "10111010101",  # ampersand (also prosign for 'WAIT')
          ";": "11101011101011101",  # semicolon
          "_": "10101110111010111",  # underscore
          "$": "10101011101010111"  # dollar sign
      }


      class mc_sync_block(gr.sync_block):
          """
          reads input from a message port
          generates a vector of Morse code bits
          """

          def __init__(self, enable=True):
              gr.sync_block.__init__(self,
                                     name="Morse code vector source",
                                     in_sig=None,
                                     out_sig=[np.byte])
              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_out(pmt.intern('clear_input'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)
              self.enable=enable
              self.textboxValue = None

          def handle_msg(self, msg):
              global textboxValue
              print(msg)
              if pmt.is_symbol(msg):
                  self.textboxValue = pmt.symbol_to_string(msg)
              else:
                  self.textboxValue = pmt.to_python(pmt.cdr(msg))
              print(textboxValue)

          def work(self, input_items, output_items):

              nbit_stream = "0000000"

              if not self.enable:
                  self.message_port_pub(pmt.intern('clear_input'), pmt.intern(''))
                  return 0

              if not self.textboxValue:
                  # nbit_stream = "0000000000000000000000"
                  return 0
              else:

                  for ch in self.textboxValue:
                      nbit_stream += (Morse.get(ch.upper()) if ch.upper() in Morse else Morse.get('?')) + "000"
                  nbit_stream += "0000000"

              #print(nbit_stream)

              for x in range(len(nbit_stream)):
                  output_items[0][x] = int(nbit_stream[x])

              # clear input line
              self.textboxValue = ""
              self.message_port_pub(pmt.intern('clear_input'), pmt.intern(''))
              return len(nbit_stream)
    enable: 'True'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import threading
      import typing as T

      import numpy as np
      import pmt
      from gnuradio import gr
      import time


      class one_shot:

          def __init__(self, delay: float, callback: T.Callable):
              self.delay = delay
              self.timer = None
              self.callback = callback
              self.last_start = None
              self.to_sleep = None
              self.thread = None

          def countdown(self):
              now = time.time_ns()
              if self.to_sleep is None:
                  self.last_start = None
                  #print("Timer timed out, at %d last_start is now %s" % (now, self.last_start))
                  self.timer.cancel()
                  self.callback()
                  return
              self.timer = threading.Timer(self.to_sleep, self.countdown)
              self.timer.start()
              self.last_start = now
              #print("Timer restarted at %d for %f seconds" % (self.last_start, self.to_sleep))
              self.to_sleep = None

          def trigger(self):
              now = time.time_ns()
              if self.last_start is None:
                  self.to_sleep = self.delay
                  self.timer = threading.Timer(self.to_sleep, self.countdown)
                  self.timer.start()
                  self.last_start = now
                  #print("Timer started at %d for %f seconds" % (self.last_start, self.to_sleep))
                  self.to_sleep = None
                  return
              else:
                  #print("Trig, last_start=%f" % self.last_start)
                  self.to_sleep = (now - self.last_start) / 1000000000
                  #print("Timer retrig at %d, To_sleep = %f" % (now, self.to_sleep))


      # noinspection PyPep8Naming
      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """VOX detector - sends a message when detecting a signal and another some time after the signal has been absent
             threshold is the signal level needed to trigger an on-air message
             attack is the number of consecutive samples needed before the message is sent
             delay is the number of seconds after the last sample over the threshold level that the off-air
             message is sent.

             The on-air message is represented by the message pair ("onair", 1) and the off-air message is represented by the
             message pair ("onair", 0)

             The output stream contains 100 zeros if the last message sent is am off-air message and 100 ones
             if the last message sent is a on-air message. Whenever a message is sent a ramp string of samples
             are sent, going from 0 to 1 on any on-air signal and from 1 to 0 on any off-air signal.

             Note that the incoming stream needs to represent the volume level of the audio, not the audio samples themselves.

             """

          def __init__(self, threshold=5, attack=10, delay=0.5):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='VOX detector',  # will show up in GRC
                  in_sig=[np.ubyte],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.threshold = threshold
              self.attack = attack
              self.delay = delay

              self.attack_counter = attack  # Counts down to 0
              self.one_shot = None
              self.message_port_register_out(pmt.intern("onair"))
              self.onair = False
              # self.to_output = []

          def send_onair_message(self):
              if not self.onair:
                  self.message_port_pub(pmt.intern("onair"), pmt.cons(pmt.string_to_symbol("onair"), pmt.to_pmt(1)))
                  self.onair = True
                  # self.ramp_up()

          def send_offair_message(self):
              if self.onair:
                  self.message_port_pub(pmt.intern("onair"), pmt.cons(pmt.string_to_symbol("onair"), pmt.to_pmt(0)))
                  self.onair = False
                  # self.ramp_down()

          def ramp_up(self):
              self.to_output = []
              for i in range(0, 128):
                  self.to_output.append(i/128)

          def ramp_down(self):
              self.to_output = []
              for i in range(0, 100):
                  self.to_output.append(1 - i/128)


          def work(self, input_items, output_items):
              #print("Input0(%d)=" % len(input_items[0]), input_items[0])
              # print("Output0(%d)=" % len(output_items[0]), output_items[0])
              for item in input_items[0]:
                  if item is not None:
                      item = -item if item < 0 else item
                      if item > self.threshold:
                          self.attack_counter -= 1
                          if self.attack_counter <= 0:
                              self.send_onair_message()
                              self.trigger_one_shot()
                              self.attack_counter = self.attack
                      else:
                          self.attack_counter = self.attack
              else:
                  self.attack_counter = self.attack

              self.consume(0, len(input_items[0]))
              # self.produce(0, 128)
              # output_items[0] = self.to_output
              # self.to_output = [1 if self.onair else 0 for i in range(0, 128)]

              # return len(output_items[0])
              return 0

          def trigger_one_shot(self):
              if self.one_shot is None:
                  self.one_shot = one_shot(self.delay, self.send_offair_message)
                  #print("Oneshot created")
              self.one_shot.trigger()
              #print("Oneshot triggered")
    attack: cw_vox_attack
    delay: (6/morse_speed * 25 + 8)*0+cw_vox_delay
    threshold: cw_vox_threshold
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import threading
      import typing as T

      import numpy as np
      import pmt
      from gnuradio import gr
      import time


      class one_shot:

          def __init__(self, delay: float, callback: T.Callable):
              self.delay = delay
              self.timer = None
              self.callback = callback
              self.last_start = None
              self.to_sleep = None
              self.thread = None

          def countdown(self):
              now = time.time_ns()
              if self.to_sleep is None:
                  self.last_start = None
                  #print("Timer timed out, at %d last_start is now %s" % (now, self.last_start))
                  self.timer.cancel()
                  self.callback()
                  return
              self.timer = threading.Timer(self.to_sleep, self.countdown)
              self.timer.start()
              self.last_start = now
              #print("Timer restarted at %d for %f seconds" % (self.last_start, self.to_sleep))
              self.to_sleep = None

          def trigger(self):
              now = time.time_ns()
              if self.last_start is None:
                  self.to_sleep = self.delay
                  self.timer = threading.Timer(self.to_sleep, self.countdown)
                  self.timer.start()
                  self.last_start = now
                  #print("Timer started at %d for %f seconds" % (self.last_start, self.to_sleep))
                  self.to_sleep = None
                  return
              else:
                  #print("Trig, last_start=%f" % self.last_start)
                  self.to_sleep = (now - self.last_start) / 1000000000
                  #print("Timer retrig at %d, To_sleep = %f" % (now, self.to_sleep))


      # noinspection PyPep8Naming
      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """VOX detector - sends a message when detecting a signal and another some time after the signal has been absent
             threshold is the signal level needed to trigger an on-air message
             attack is the number of consecutive samples needed before the message is sent
             delay is the number of seconds after the last sample over the threshold level that the off-air
             message is sent.

             The on-air message is represented by the message pair ("onair", 1) and the off-air message is represented by the
             message pair ("onair", 0)

             The output stream contains 100 zeros if the last message sent is am off-air message and 100 ones
             if the last message sent is a on-air message. Whenever a message is sent a ramp string of samples
             are sent, going from 0 to 1 on any on-air signal and from 1 to 0 on any off-air signal.

             Note that the incoming stream needs to represent the volume level of the audio, not the audio samples themselves.

             """

          def __init__(self, threshold=5, attack=10, delay=0.5):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='VOX detector',  # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.threshold = threshold
              self.attack = attack
              self.delay = delay

              self.attack_counter = attack  # Counts down to 0
              self.one_shot = None
              self.message_port_register_out(pmt.intern("onair"))
              self.onair = False
              # self.to_output = []

          def send_onair_message(self):
              if not self.onair:
                  self.message_port_pub(pmt.intern("onair"), pmt.cons(pmt.string_to_symbol("onair"), pmt.to_pmt(1)))
                  self.onair = True
                  # self.ramp_up()

          def send_offair_message(self):
              if self.onair:
                  self.message_port_pub(pmt.intern("onair"), pmt.cons(pmt.string_to_symbol("onair"), pmt.to_pmt(0)))
                  self.onair = False
                  # self.ramp_down()

          def ramp_up(self):
              self.to_output = []
              for i in range(0, 128):
                  self.to_output.append(i/128)

          def ramp_down(self):
              self.to_output = []
              for i in range(0, 100):
                  self.to_output.append(1 - i/128)


          def work(self, input_items, output_items):
              # print("Input0(%f)=" % len(input_items[0]), input_items[0])
              # print("Output0(%d)=" % len(output_items[0]), output_items[0])
              for item in input_items[0]:
                  if item is not None:
                      item = -item if item < 0 else item
                      if item > self.threshold:
                          self.attack_counter -= 1
                          if self.attack_counter <= 0:
                              self.send_onair_message()
                              self.trigger_one_shot()
                              self.attack_counter = self.attack
                      else:
                          self.attack_counter = self.attack
              else:
                  self.attack_counter = self.attack

              self.consume(0, len(input_items[0]))
              # self.produce(0, 128)
              # output_items[0] = self.to_output
              # self.to_output = [1 if self.onair else 0 for i in range(0, 128)]

              # return len(output_items[0])
              return 0

          def trigger_one_shot(self):
              if self.one_shot is None:
                  self.one_shot = one_shot(self.delay, self.send_offair_message)
                  # print("Oneshot created")
              self.one_shot.trigger()
              # print("Oneshot triggered")
    attack: vox_attack[mode]
    delay: vox_delay[mode]
    threshold: vox_threshold[mode]
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import time


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Message gate. This module either transfer messages reads a message from the input port and
              applies a python expression on it before sending it along on the output port

              Parameters:
                  expr: String. The expression to apply. May use variables."""

          def __init__(self, offset=0, factor=10):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Message mangler',  # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )

              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_out(pmt.intern('msg_out'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)
              self.offset=offset
              self.factor=factor
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).


          def handle_msg(self, msg):
                  adj = self.factor*pmt.to_python(pmt.cdr(msg))
                  new_value = self.offset + adj
                  print(adj, new_value)
                  p = pmt.to_pmt(new_value)
                  self.message_port_pub(pmt.intern("msg_out"), pmt.cons(pmt.intern("fq"), p))
                  time.sleep(0.1)
                  self.message_port_pub(pmt.intern("msg_out"), pmt.cons(pmt.intern("fq"), p))
    factor: '1'
    offset: '0'
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: ssb_tx_bandwidth
    decim: '1'
    gain: '1'
    samp_rate: tx_samp_rate
    type: ccc
    width: '50'
    win: window.WIN_RECTANGULAR
  states: {}
- name: filter_fft_low_pass_filter_0_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: ssb_tx_bandwidth/2-200
    decim: '2'
    gain: '1'
    samp_rate: audio_samp_rate
    type: fff
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: filter_fft_low_pass_filter_0_0_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: ssb_tx_bandwidth/2-200
    decim: '2'
    gain: '1'
    samp_rate: audio_samp_rate
    type: fff
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: filter_fft_low_pass_filter_0_1_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: 1e6
    decim: int(tx_samp_rate/tx_samp_rate_out)
    gain: '1'
    samp_rate: tx_samp_rate
    type: ccc
    width: '50'
    win: window.WIN_RECTANGULAR
  states: {}
- name: freq_xlating_fft_filter_ccc_1
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: filter_fq+cw_midear_beat[side_band_rx]
    decim: int(rx_samp_rate/if0_samp_rate)
    samp_rate: rx_samp_rate
    taps: firdes.low_pass(1,rx_samp_rate,rx_samp_rate/(2*1),3900)
  states: {}
- name: freq_xlating_fft_filter_ccc_1_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: filter_fq-cw_midear_beat[side_band_rx]
    decim: int(rx_samp_rate/if0_samp_rate)
    samp_rate: rx_samp_rate
    taps: firdes.low_pass(1,rx_samp_rate,rx_samp_rate/(2*1),3900)
  states: {}
- name: freq_xlating_fft_filter_ccc_1_0_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: filter_fq
    decim: '1'
    samp_rate: rx_samp_rate
    taps: firdes.low_pass(1,rx_samp_rate,rx_samp_rate/(2*1),3900)
  states: {}
- name: frequency_counter
  id: note
  parameters:
    note: '''{:.0f}''.format((lo_freq_Hz[freq_chooser]+tune+fine_tune))'
  states: {}
- name: msg_formatter
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Message gate. This module either transfer messages reads a message from the input port and
              applies a python expression on it before sending it along on the output port

              Parameters:
                  expr: String. The expression to apply. May use variables."""

          def __init__(self, variables=None):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Message formatter',  # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )

              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_out(pmt.intern('msg_out'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)

              self._variables=variables
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).


          @property
          def variables(self):
              """The gate control parameter tells whether messages are to be transferred or not"""
              return self._variables

          @variables.setter
          def variables(self, value):
              self._variables = value
              print("Variables set to", self._variables)

          @variables.deleter
          def variables(self):
              del self._variables



          def handle_msg(self, msg):
                  new_value = pmt.to_python(pmt.cdr(msg)) % self._variables
                  p = pmt.to_pmt(new_value)
                  self.message_port_pub(pmt.intern("msg_out"), pmt.cons(pmt.intern("msg"), p))
    variables: (dx_call)
  states: {}
- name: msg_formatter_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Message gate. This module either transfer messages reads a message from the input port and
              applies a python expression on it before sending it along on the output port

              Parameters:
                  expr: String. The expression to apply. May use variables."""

          def __init__(self, variables=None):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Message formatter',  # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )

              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_out(pmt.intern('msg_out'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)

              self._variables=variables
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).


          @property
          def variables(self):
              """The gate control parameter tells whether messages are to be transferred or not"""
              return self._variables

          @variables.setter
          def variables(self, value):
              self._variables = value
              print("Variables set to", self._variables)

          @variables.deleter
          def variables(self):
              del self._variables



          def handle_msg(self, msg):
                  new_value = pmt.to_python(pmt.cdr(msg)) % self._variables
                  p = pmt.to_pmt(new_value)
                  self.message_port_pub(pmt.intern("msg_out"), pmt.cons(pmt.intern("msg"), p))
    variables: (dx_call, tx_rprt, tx_rprt, tx_rprt, dx_call)
  states: {}
- name: msg_formatter_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Message gate. This module either transfer messages reads a message from the input port and
              applies a python expression on it before sending it along on the output port

              Parameters:
                  expr: String. The expression to apply. May use variables."""

          def __init__(self, variables=None):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Message formatter',  # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )

              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_out(pmt.intern('msg_out'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)

              self._variables=variables
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).


          @property
          def variables(self):
              """The gate control parameter tells whether messages are to be transferred or not"""
              return self._variables

          @variables.setter
          def variables(self, value):
              self._variables = value
              print("Variables set to", self._variables)

          @variables.deleter
          def variables(self):
              del self._variables



          def handle_msg(self, msg):
                  new_value = pmt.to_python(pmt.cdr(msg)) % self._variables
                  p = pmt.to_pmt(new_value)
                  self.message_port_pub(pmt.intern("msg_out"), pmt.cons(pmt.intern("msg"), p))
    variables: (dx_call, tx_rprt, tx_rprt, tx_rprt)
  states: {}
- name: msg_formatter_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Message gate. This module either transfer messages reads a message from the input port and
              applies a python expression on it before sending it along on the output port

              Parameters:
                  expr: String. The expression to apply. May use variables."""

          def __init__(self, variables=None):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Message formatter',  # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )

              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_out(pmt.intern('msg_out'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)

              self._variables=variables
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).


          @property
          def variables(self):
              """The gate control parameter tells whether messages are to be transferred or not"""
              return self._variables

          @variables.setter
          def variables(self, value):
              self._variables = value
              print("Variables set to", self._variables)

          @variables.deleter
          def variables(self):
              del self._variables



          def handle_msg(self, msg):
                  new_value = pmt.to_python(pmt.cdr(msg)) % self._variables
                  p = pmt.to_pmt(new_value)
                  self.message_port_pub(pmt.intern("msg_out"), pmt.cons(pmt.intern("msg"), p))
    variables: (dx_call)
  states: {}
- name: msg_formatter_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Message gate. This module either transfer messages reads a message from the input port and
              applies a python expression on it before sending it along on the output port

              Parameters:
                  expr: String. The expression to apply. May use variables."""

          def __init__(self, variables=None):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Message formatter',  # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )

              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_out(pmt.intern('msg_out'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)

              self._variables=variables
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).


          @property
          def variables(self):
              """The gate control parameter tells whether messages are to be transferred or not"""
              return self._variables

          @variables.setter
          def variables(self, value):
              self._variables = value
              print("Variables set to", self._variables)

          @variables.deleter
          def variables(self):
              del self._variables



          def handle_msg(self, msg):
                  new_value = pmt.to_python(pmt.cdr(msg)) % self._variables
                  print(new_value, self._variables)
                  p = pmt.to_pmt(new_value)
                  self.message_port_pub(pmt.intern("msg_out"), pmt.cons(pmt.intern("msg"), p))
    variables: cq_flavors[cq_flavor]
  states: {}
- name: mulc_usb1
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: mulc_usb_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: mulc_usb_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: mulc_usb_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: note_0
  id: note
  parameters:
    note: The two chains decode USB and LSB separately. In CW stereo mode the center frequencies are split 1740 Hz apart.
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: USB RX chain
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: Waterfall RX chain
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: LSB RX chain
  states: {}
- name: note_0_1_0
  id: note
  parameters:
    note: WBFM RX chain
  states: {}
- name: note_0_1_0_0
  id: note
  parameters:
    note: NBFM RX chain
  states: {}
- name: note_0_1_0_0_0
  id: note
  parameters:
    note: AM RX chain
  states: {}
- name: note_0_1_1
  id: note
  parameters:
    note: S meter chain
  states: {}
- name: note_1
  id: note
  parameters:
    note: SSB TRANSMITTER SECTION
  states: {}
- name: note_2
  id: note
  parameters:
    note: CW transmiter section
  states: {}
- name: note_2_0
  id: note
  parameters:
    note: NBFM transmiter section
  states: {}
- name: note_3
  id: note
  parameters:
    note: 'CW GUI '
  states: {}
- name: note_5
  id: note
  parameters:
    note: CONTROL SECTION
  states: {}
- name: note_6
  id: note
  parameters:
    note: SSB/CW receiver section
  states: {}
- name: note_7
  id: note
  parameters:
    note: Transmit signal selector and output
  states: {}
- name: op_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 4,4,3,2
    label0: SSB
    label1: MGM
    label2: CW
    num_tabs: '3'
  states: {}
- name: pfb_decimator_ccf_0_0
  id: pfb_decimator_ccf
  parameters:
    atten: '60'
    channel: '0'
    decim: int(if0_samp_rate/if_samp_rate)
    taps: firdes.low_pass(1,if0_samp_rate/2, 3900,100)
  states: {}
- name: pfb_decimator_ccf_0_0_0
  id: pfb_decimator_ccf
  parameters:
    atten: '60'
    channel: '0'
    decim: int(if0_samp_rate/if_samp_rate)
    taps: firdes.low_pass(1,if0_samp_rate/2, 3900,100)
  states: {}
- name: pfb_decimator_ccf_0_0_0_0
  id: pfb_decimator_ccf
  parameters:
    atten: '60'
    channel: '0'
    decim: int(if0_samp_rate/wbfm_if2_samp_rate)
    taps: firdes.low_pass(1,if0_samp_rate/2, 100000,1000)
  states: {}
- name: pfb_decimator_ccf_0_0_1
  id: pfb_decimator_ccf
  parameters:
    atten: '60'
    channel: '0'
    decim: int(if0_samp_rate/wbfm_if2_samp_rate)
    taps: firdes.low_pass(1,if0_samp_rate/2, 5000,200)
  states: {}
- name: pfb_decimator_ccf_0_0_2
  id: pfb_decimator_ccf
  parameters:
    atten: '60'
    channel: '0'
    decim: int(if0_samp_rate/if2_samp_rate)
    taps: firdes.low_pass(1,if_samp_rate/2, 3900,100)
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: op_tab@2:2,0,1,3
    is_pair: 'False'
    label: 'CW message to send:'
    type: string
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Microphone"'
    type: float
  states: {state: disabled}
- name: qtgui_ledindicator_0_0
  id: qtgui_ledindicator
  parameters:
    gui_hint: 1,5,1,1
    label: ON AIR
    maxSize: '20'
    offColor: black
    onColor: red
    state: (ssb_txing or ssb_txing_btn or cw_txing)
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: fft_bw_desired
    fc: fft_center_fq
    fftsize: '4096'
    gui_hint: 4,0,3,4
    plotconst: 'False'
    plotfreq: 'False'
    plottime: 'False'
    showports: 'True'
    showrf: 'True'
    type: complex
    wintype: window.WIN_HANN
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: fft_bw_desired
    fc: fft_center_fq
    fftsize: '1024'
    gui_hint: 4,0,3,4
    showports: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(if2_samp_rate/1000)
    fbw: '0.4'
    interp: int(audio_samp_rate/1000)
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(if2_samp_rate/1000)
    fbw: '0.4'
    interp: int(audio_samp_rate/1000)
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(wbfm_if2_samp_rate/10000)
    fbw: '0.4'
    interp: int(audio_samp_rate/1000)
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(wbfm_if2_samp_rate/10000)
    fbw: '0.4'
    interp: int(audio_samp_rate/1000)
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0_1
  id: rational_resampler_xxx
  parameters:
    decim: int(if2_samp_rate/1000)
    fbw: '0.4'
    interp: int(audio_samp_rate/1000)
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: int(cw_samp_rate/1000)
    fbw: '0.4'
    interp: int(audio_samp_rate/1000)
    type: fff
  states: {}
- name: rational_resampler_xxx_4_0
  id: rational_resampler_xxx
  parameters:
    comment: This block turns the SSB signal into a stream of RF samples.
    decim: '1'
    interp: int(2*tx_samp_rate/audio_samp_rate)
    type: ccc
  states: {}
- name: rational_resampler_xxx_4_0_0
  id: rational_resampler_xxx
  parameters:
    comment: This block turns the FM signal into a stream of RF samples.
    decim: int(audio_samp_rate/1000)
    interp: int(tx_samp_rate/4000)
    type: ccc
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '200'
    samp_rate: cw_samp_rate
    sym_rate: morse_speed*8.33/50
    type: fir_filter_fff
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '200'
    samp_rate: cw_samp_rate
    sym_rate: morse_speed*8.33/50
    type: fir_filter_fff
  states: {}
- name: rx_distancer
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Rx distancer. This module aims at making sure that the hardware receive frequency is kept within a defined range of hz below the desired frequency,
          and that the remaining difference is set into a variable. Only when the desired frequency would result in the hardware receive frequency
          would go outside the limits, the frequencies will be changed.
          The desired frequency is received through the message port.
          New hardware and filter frequencies are sent through the hw_fq_out, and the filter:fq_out ports.
          For proper operation, these ports should be connected to Messsage_pair_to_var blocks that
          transfer the new values back to the hw_var and filter_var variables respectively. If not, the operation of this block is undefined.

               """

          def __init__(self, desired_fq=0.0, min_distance=100e3, max_distance=1e6, hw_var=None, filter_var=None):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Rx distancer',  # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )

              self.message_port_register_in(pmt.intern('freq_in'))
              self.set_msg_handler(pmt.intern('freq_in'), self.handle_msg)
              self.message_port_register_out(pmt.intern("hw_fq_out"))
              self.message_port_register_out(pmt.intern("filter_fq_out"))

              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

              self.min_distance=min_distance
              self.max_distance=max_distance
              self._desired_fq=desired_fq
              self.hw_var=hw_var
              self.filter_var=filter_var
              # gr.log.error("Desired fq %f initially" % desired_fq)
              if desired_fq:
                  self.compute_and_send(desired_fq)  # Initialize desired fq

          def compute_and_send(self, new_val):
              hw_var = self.hw_var
              # gr.log.error("New value %f" % new_val)

              hw_chunk = (self.max_distance - self.min_distance) / 2.0
              # gr.log.error("Chunk size= %f" % hw_chunk)

              distance = new_val - hw_var
              # gr.log.error("Distance = %f" % distance)

              while distance > self.max_distance:
                  # gr.log.error("Distance = %f" % distance)
                  hw_var += hw_chunk
                  # gr.log.error("HW var = %f" % hw_var)
                  distance = new_val - hw_var

              while distance < self.min_distance:
                  # gr.log.error("Distance = %f" % distance)
                  hw_var -= hw_chunk
                  # gr.log.error("HW var = %f" % hw_var)
                  distance = new_val - hw_var

              # gr.log.error("New HW var = %f" % hw_var)


              if hw_var != self.hw_var:
                  gr.log.info("New HW fq = %f" % hw_var)
                  self.message_port_pub(pmt.intern("hw_fq_out"), pmt.cons(pmt.intern("hw_fq"), pmt.to_pmt(hw_var)))
              new_filter = new_val - hw_var

              # gr.log.error("New filter var = %f" % new_filter)

              if new_filter != self.filter_var:
                  gr.log.info("New filter var = %f" % new_filter)
                  self.message_port_pub(pmt.intern("filter_fq_out"), pmt.cons(pmt.intern("filter_fq"), pmt.to_pmt(new_filter)))
              pass

          @property
          def desired_fq(self):
              """The gate control parameter tells whether messages are to be transferred or not"""
              return self._desired_fq

          @desired_fq.setter
          def desired_fq(self, value):
              self._desired_fq = value
              self.compute_and_send(value)

          @desired_fq.deleter
          def desired_fq(self):
              del self._desired_fq


          def handle_msg(self, msg):
              if not pmt.is_pair(msg) or pmt.is_dict(msg) or pmt.is_pdu(msg):
                  gr.log.warn("Input message %s is not a simple pair, dropping" % repr(msg))
                  return
              # gr.log.error("Input message %s received" % repr(msg))
              # gr.log.error("Max distance %d" % self.max_distance)
              # gr.log.error("Min distance %d" % self.min_distance)

              new_val = pmt.to_python(pmt.cdr(msg))

              self.compute_and_send(new_val)



          def stop(self):
              return True
    comment: |-
      Selects hardware receiver frequency and demodulator offset given desired listening fq.
      Keeps demodulator offset within the passband of hardware receiver,
    desired_fq: current_default_fq
    filter_var: filter_fq
    hw_var: rx_hw_fq
    max_distance: rx_samp_rate/2.0
    min_distance: 100e3
  states: {}
- name: settings_tab
  id: qtgui_tab_widget
  parameters:
    label0: RX_settings
    label1: TX_settings
    label2: Debug
    label3: AGC
    num_tabs: '4'
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    amp: 'True'
    bandwidth: tx_bw[tx_bw_opts]
    center_freq: tx_fq+tx_mode_offset[side_band_tx] + fq_calibration
    dev_args: driver=remote,remote=tcp:://192.168.1.125:1234,remote:type=hackrf
    samp_rate: tx_samp_rate_out
    type: fc32
    vga: tx_gain
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: rx_preamp
    center_freq: rx_hw_fq + fq_calibration
    dev_args: driver=remote,remote=tcp://192.168.1.125:1234,remote:type=hackrf
    gain: lna_gain
    samp_rate: rx_samp_rate
    type: fc32
    vga: vga_gain
  states: {}
- name: tx_fq_sync
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      import time

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Message gate. This module either transfer messages from the input port to the output port, or not.
              Parameters:
                  gate_control(R): Boolean, true transfers messages, false swallows them
                  resync(R): If true, the last swallowed message will be sent when the message gate opens
                  repeat(R): Defines how many copies of each message to send. (Used to work around a bug in QT DigitalNumberControl)"""

          def __init__(self, gate_control=True, resync=True, repeat=1):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Message Gate',  # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )

              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_out(pmt.intern('msg_out'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.last_msg = None
              self.resync = resync
              self.repeat = repeat


              self._gate_control = gate_control

          @property
          def gate_control(self):
              """The gate control parameter tells whether messages are to be transferred or not"""
              return self._gate_control

          @gate_control.setter
          def gate_control(self, value):
              if self.resync and value and value != self._gate_control and self.last_msg is not None:
                  for i in range(self.repeat):
                      self.message_port_pub(pmt.intern('msg_out'), self.last_msg)
                      time.sleep(0.1)
                  self.last_msg = None
              self._gate_control = value

          @gate_control.deleter
          def gate_control(self):
              del self._gate_control

          def handle_msg(self, msg):
              if self.gate_control:
                  for i in range(self.repeat):
                      self.message_port_pub(pmt.intern('msg_out'), msg)
                      time.sleep(0.1)
              else:
                  self.last_msg = msg
    comment: |-
      Transfers RX frequency changes to the 
      Tx freq iff the split_fq checkbox is *not* checked
    gate_control: split_fq
    repeat: '2'
    resync: 'True'
  states: {}
- name: variable_qtgui_msg_push_button_0_0
  id: variable_qtgui_msg_push_button
  parameters:
    gui_hint: op_tab@2:1,1,1,1
    label: CALL CQ
    msgName: ''
    relBackgroundColor: white
    relFontColor: black
    type: string
    value: CQ%s CQ%s CQ%s DE SM6FBQ SM6FBQ %sk
  states: {}
- name: variable_qtgui_msg_push_button_0_0_0
  id: variable_qtgui_msg_push_button
  parameters:
    gui_hint: op_tab@2:4,0,1,1
    label: Call DX
    msgName: ''
    relBackgroundColor: white
    relFontColor: black
    type: string
    value: '%s de SM6FBQ'
  states: {}
- name: variable_qtgui_msg_push_button_0_0_0_0
  id: variable_qtgui_msg_push_button
  parameters:
    gui_hint: op_tab@2:5,0,1,1
    label: Send report
    msgName: ''
    relBackgroundColor: white
    relFontColor: black
    type: string
    value: '%s de SM6FBQ UR %s %s %s/ JO67BQ JO67BQ HW? %s de SM6FBQ k'
  states: {}
- name: variable_qtgui_msg_push_button_0_0_0_0_0
  id: variable_qtgui_msg_push_button
  parameters:
    gui_hint: op_tab@2:6,0,1,1
    label: Send  R & report
    msgName: ''
    relBackgroundColor: white
    relFontColor: black
    type: string
    value: '%s de SM6FBQ R FB  UR %s %s %s/ JO67BQ JO67BQ HW? bk'
  states: {}
- name: variable_qtgui_msg_push_button_0_0_0_0_0_0
  id: variable_qtgui_msg_push_button
  parameters:
    gui_hint: op_tab@2:7,0,1,1
    label: Send  RR 73
    msgName: ''
    relBackgroundColor: white
    relFontColor: black
    type: string
    value: '%s de SM6FBQ RR FB  73 Hej ee'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: msg_debug
  states: {state: disabled}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: rrc
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: msg_debug_0
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: msg_debug_1
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: msg_debug_2
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: set_rx_freq
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: msg_debug_3
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: msg_debug
  states: {state: disabled}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: msg_debug_2
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: rrc
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: msg_debug_3
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: clear_cw_msg
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: msg_debug_0
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: msg_debug_1
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: set_rx_freq
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:8879
    timeout: '100'
    type: float
  states: {state: disabled}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:8755
    comment: Receives frequency updates from WSJT-X
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:8754
    comment: Sends frequency changes to WSJT-X
    timeout: '100'
  states: {state: disabled}

connections:
- [analog_agc2_xx_0, '0', blocks_multiply_const_vxx_1_0_0_0_0, '0']
- [analog_agc3_xx_0, '0', rational_resampler_xxx_0, '0']
- [analog_agc3_xx_0_0, '0', rational_resampler_xxx_0_0_0, '0']
- [analog_am_demod_cf_0, '0', blocks_multiply_const_vxx_1_0_1_0_1_0_0_0, '0']
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_1_0_1_0_1_0_0, '0']
- [analog_nbfm_tx_0, '0', blocks_selector_0_0, '0']
- [analog_pll_carriertracking_cc_0, '0', analog_am_demod_cf_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_1, '0']
- [analog_sig_source_x_1_0, '0', blocks_multiply_xx_0_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_agc3_xx_0, '0']
- [analog_simple_squelch_cc_0_0, '0', analog_agc3_xx_0_0, '0']
- [analog_simple_squelch_cc_0_1, '0', analog_nbfm_rx_0, '0']
- [analog_simple_squelch_cc_0_1_0, '0', analog_wfm_rcv_pll_0, '0']
- [analog_wfm_rcv_pll_0, '0', blocks_multiply_const_vxx_1_0_1_0_1, '0']
- [analog_wfm_rcv_pll_0, '1', blocks_multiply_const_vxx_1_0_1_0_1_0, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_1_0_0_0, '0']
- [audio_source_0_0, '0', analog_agc2_xx_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_1_0_0_1, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_0_0, '1']
- [band_pass_filter_0, '0', blocks_multiply_xx_0_0_0, '0']
- [band_pass_filter_0_0, '0', blocks_complex_to_float_0_1_0, '0']
- [band_pass_filter_0_1, '0', blocks_complex_to_float_0_2_0_0, '0']
- [band_pass_filter_0_2, '0', analog_nbfm_tx_0, '0']
- [blocks_add_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_complex_to_float_0_1_0, '0', blocks_float_to_complex_0_0_0, '1']
- [blocks_complex_to_float_0_1_0, '1', mulc_usb_0_0_0, '0']
- [blocks_complex_to_float_0_2, '0', blocks_float_to_complex_0_1, '1']
- [blocks_complex_to_float_0_2, '1', mulc_usb_0_0, '0']
- [blocks_complex_to_float_0_2_0, '0', blocks_float_to_complex_0_1_0, '1']
- [blocks_complex_to_float_0_2_0, '1', mulc_usb_0, '0']
- [blocks_complex_to_float_0_2_0_0, '0', blocks_float_to_complex_0_1_0_0, '1']
- [blocks_complex_to_float_0_2_0_0, '1', mulc_usb1, '0']
- [blocks_complex_to_float_0_2_0_1, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_matrix_xx_0, '1']
- [blocks_complex_to_real_0_0_0, '0', blocks_multiply_matrix_xx_0, '0']
- [blocks_delay_0, '0', blocks_selector_1, '2']
- [blocks_delay_0_0, '0', blocks_multiply_xx_0, '0']
- [blocks_float_to_char_0, '0', epy_block_1, '0']
- [blocks_float_to_complex_0_0_0, '0', analog_simple_squelch_cc_0, '0']
- [blocks_float_to_complex_0_0_0, '0', blocks_add_xx_0, '1']
- [blocks_float_to_complex_0_0_1, '0', blocks_selector_0, '0']
- [blocks_float_to_complex_0_1, '0', band_pass_filter_0_0, '0']
- [blocks_float_to_complex_0_1_0, '0', band_pass_filter_0_1, '0']
- [blocks_float_to_complex_0_1_0_0, '0', analog_simple_squelch_cc_0_0, '0']
- [blocks_float_to_complex_0_1_0_0, '0', blocks_add_xx_0, '0']
- [blocks_float_to_complex_0_3, '0', blocks_repeat_0_0, '0']
- [blocks_float_to_complex_0_3_0, '0', blocks_selector_1, '2']
- [blocks_float_to_int_0, '0', blocks_probe_signal_x_0, '0']
- [blocks_integrate_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_integrate_xx_1, '0', blocks_float_to_char_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_complex_to_float_0_2_0_1, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_sink_x_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_keep_one_in_n_0_0, '0', blocks_add_xx_0, '2']
- [blocks_keep_one_in_n_0_1, '0', blocks_add_xx_0, '3']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_delay_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_float_to_complex_0_3, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_integrate_xx_1, '0']
- [blocks_multiply_const_vxx_1_0, '0', audio_sink_0_1, '1']
- [blocks_multiply_const_vxx_1_0, '0', blocks_null_sink_0_0, '0']
- [blocks_multiply_const_vxx_1_0_0, '0', audio_sink_0_2, '1']
- [blocks_multiply_const_vxx_1_0_0, '0', blocks_null_sink_0_2, '0']
- [blocks_multiply_const_vxx_1_0_0_0, '0', blocks_selector_2, '1']
- [blocks_multiply_const_vxx_1_0_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_1_0_0_0_0, '0', band_pass_filter_0_2, '0']
- [blocks_multiply_const_vxx_1_0_0_0_0, '0', blocks_selector_2, '2']
- [blocks_multiply_const_vxx_1_0_0_1, '0', epy_block_1_0, '0']
- [blocks_multiply_const_vxx_1_0_1_0, '0', audio_sink_0_1, '0']
- [blocks_multiply_const_vxx_1_0_1_0, '0', blocks_null_sink_0, '0']
- [blocks_multiply_const_vxx_1_0_1_0_0, '0', audio_sink_0_2, '0']
- [blocks_multiply_const_vxx_1_0_1_0_0, '0', blocks_null_sink_0_1, '0']
- [blocks_multiply_const_vxx_1_0_1_0_1, '0', blocks_multiply_matrix_xx_0, '2']
- [blocks_multiply_const_vxx_1_0_1_0_1_0, '0', blocks_multiply_matrix_xx_0, '3']
- [blocks_multiply_const_vxx_1_0_1_0_1_0_0, '0', blocks_multiply_matrix_xx_0, '4']
- [blocks_multiply_const_vxx_1_0_1_0_1_0_0_0, '0', blocks_multiply_matrix_xx_0, '5']
- [blocks_multiply_const_vxx_4_0, '0', blocks_complex_to_float_0_2, '0']
- [blocks_multiply_const_vxx_4_0_0, '0', blocks_complex_to_float_0_2_0, '0']
- [blocks_multiply_const_vxx_4_0_1, '0', blocks_keep_one_in_n_0_0, '0']
- [blocks_multiply_const_vxx_4_0_1, '0', rational_resampler_xxx_0_0_0_0, '0']
- [blocks_multiply_const_vxx_4_0_1_0, '0', blocks_keep_one_in_n_0_1, '0']
- [blocks_multiply_const_vxx_4_0_1_0, '0', rational_resampler_xxx_0_0_0_0_0, '0']
- [blocks_multiply_const_vxx_4_0_2, '0', blocks_add_xx_0, '4']
- [blocks_multiply_const_vxx_4_0_2, '0', rational_resampler_xxx_0_0_0_1, '0']
- [blocks_multiply_matrix_xx_0, '0', blocks_multiply_const_vxx_1_0_1_0, '0']
- [blocks_multiply_matrix_xx_0, '0', blocks_multiply_const_vxx_1_0_1_0_0, '0']
- [blocks_multiply_matrix_xx_0, '1', blocks_multiply_const_vxx_1_0, '0']
- [blocks_multiply_matrix_xx_0, '1', blocks_multiply_const_vxx_1_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_xx_0_0, '0', filter_fft_low_pass_filter_0_0, '0']
- [blocks_multiply_xx_0_0_0, '0', filter_fft_low_pass_filter_0_0_0, '0']
- [blocks_multiply_xx_1, '0', blocks_float_to_complex_0_3_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_float_to_int_0, '0']
- [blocks_nlog10_ff_0, '0', zeromq_pub_sink_0, '0']
- [blocks_null_source_1, '0', blocks_selector_2, '0']
- [blocks_repeat_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_repeat_0_0, '0', blocks_delay_0, '0']
- [blocks_selector_0, '0', blocks_null_sink_2, '0']
- [blocks_selector_0, '1', rational_resampler_xxx_4_0, '0']
- [blocks_selector_0_0, '0', blocks_null_sink_2_0, '0']
- [blocks_selector_0_0, '1', rational_resampler_xxx_4_0_0, '0']
- [blocks_selector_1, '0', blocks_null_sink_2_0_0, '0']
- [blocks_selector_1, '1', blocks_file_sink_0, '0']
- [blocks_selector_1, '1', filter_fft_low_pass_filter_0_1_0, '0']
- [blocks_selector_2, '0', band_pass_filter_0, '0']
- [blocks_uchar_to_float_0, '0', virtual_sink_0_1, '0']
- [cw_msg_in, '0', epy_block_0_0, msg_in]
- [epy_block_0_0, '0', blocks_repeat_0, '0']
- [epy_block_0_0, clear_input, clear_cw_msg, '0']
- [epy_block_1, onair, blocks_msgpair_to_var_0, inpair]
- [epy_block_1, onair, virtual_sink_0, '0']
- [epy_block_1_0, onair, blocks_msgpair_to_var_0_0, inpair]
- [epy_block_1_0, onair, virtual_sink_1, '0']
- [epy_block_2, msg_out, virtual_sink_3, '0']
- [epy_block_2, msg_out, virtual_sink_4, '0']
- [filter_fft_low_pass_filter_0, '0', blocks_selector_1, '0']
- [filter_fft_low_pass_filter_0_0, '0', blocks_float_to_complex_0_0_1, '0']
- [filter_fft_low_pass_filter_0_0_0, '0', blocks_float_to_complex_0_0_1, '1']
- [filter_fft_low_pass_filter_0_1_0, '0', soapy_hackrf_sink_0, '0']
- [freq_xlating_fft_filter_ccc_1, '0', pfb_decimator_ccf_0_0, '0']
- [freq_xlating_fft_filter_ccc_1, '0', pfb_decimator_ccf_0_0_0_0, '0']
- [freq_xlating_fft_filter_ccc_1, '0', pfb_decimator_ccf_0_0_1, '0']
- [freq_xlating_fft_filter_ccc_1, '0', pfb_decimator_ccf_0_0_2, '0']
- [freq_xlating_fft_filter_ccc_1_0, '0', pfb_decimator_ccf_0_0_0, '0']
- [freq_xlating_fft_filter_ccc_1_0_0, '0', blocks_keep_one_in_n_0, '0']
- [msg_formatter, msg_out, cq_msg_in, '0']
- [msg_formatter_0, msg_out, cq_msg_in, '0']
- [msg_formatter_0_0, msg_out, cq_msg_in, '0']
- [msg_formatter_0_0_0, msg_out, cq_msg_in, '0']
- [msg_formatter_1, msg_out, cq_msg_in, '0']
- [mulc_usb1, '0', blocks_float_to_complex_0_1_0_0, '0']
- [mulc_usb_0, '0', blocks_float_to_complex_0_1_0, '0']
- [mulc_usb_0_0, '0', blocks_float_to_complex_0_1, '0']
- [mulc_usb_0_0_0, '0', blocks_float_to_complex_0_0_0, '0']
- [pfb_decimator_ccf_0_0, '0', blocks_multiply_const_vxx_4_0, '0']
- [pfb_decimator_ccf_0_0_0, '0', blocks_multiply_const_vxx_4_0_0, '0']
- [pfb_decimator_ccf_0_0_0_0, '0', blocks_multiply_const_vxx_4_0_1, '0']
- [pfb_decimator_ccf_0_0_1, '0', blocks_multiply_const_vxx_4_0_1_0, '0']
- [pfb_decimator_ccf_0_0_2, '0', blocks_multiply_const_vxx_4_0_2, '0']
- [qtgui_edit_box_msg_0, msg, cq_msg_in, '0']
- [qtgui_sink_x_0, freq, epy_block_2, msg_in]
- [qtgui_sink_x_0, freq, virtual_sink_5, '0']
- [qtgui_waterfall_sink_x_0, freq, epy_block_2, msg_in]
- [qtgui_waterfall_sink_x_0, freq, virtual_sink_5, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_real_0, '0']
- [rational_resampler_xxx_0_0_0, '0', blocks_complex_to_real_0_0_0, '0']
- [rational_resampler_xxx_0_0_0_0, '0', analog_simple_squelch_cc_0_1_0, '0']
- [rational_resampler_xxx_0_0_0_0_0, '0', analog_simple_squelch_cc_0_1, '0']
- [rational_resampler_xxx_0_0_0_1, '0', analog_pll_carriertracking_cc_0, '0']
- [rational_resampler_xxx_1, '0', audio_sink_0_0, '0']
- [rational_resampler_xxx_4_0, '0', filter_fft_low_pass_filter_0, '0']
- [rational_resampler_xxx_4_0_0, '0', blocks_selector_1, '1']
- [root_raised_cosine_filter_0, '0', root_raised_cosine_filter_0_0, '0']
- [root_raised_cosine_filter_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [root_raised_cosine_filter_0_0, '0', blocks_multiply_xx_1, '1']
- [rx_distancer, filter_fq_out, blocks_msgpair_to_var_1_0_0, inpair]
- [rx_distancer, hw_fq_out, blocks_msgpair_to_var_1_0, inpair]
- [rx_fq_win, valueout, blocks_msgpair_to_var_1, inpair]
- [rx_fq_win, valueout, rx_distancer, freq_in]
- [rx_fq_win, valueout, tx_fq_sync, msg_in]
- [rx_fq_win, valueout, zeromq_push_msg_sink_0, in]
- [soapy_hackrf_source_0, '0', freq_xlating_fft_filter_ccc_1, '0']
- [soapy_hackrf_source_0, '0', freq_xlating_fft_filter_ccc_1_0, '0']
- [soapy_hackrf_source_0, '0', freq_xlating_fft_filter_ccc_1_0_0, '0']
- [tx_fq_sync, msg_out, tx_fq_win, valuein]
- [tx_fq_win, valueout, blocks_msgpair_to_var_1_1, inpair]
- [tx_fq_win, valueout, virtual_sink_2, '0']
- [variable_qtgui_msg_push_button_0_0, pressed, msg_formatter_1, msg_in]
- [variable_qtgui_msg_push_button_0_0_0, pressed, msg_formatter, msg_in]
- [variable_qtgui_msg_push_button_0_0_0_0, pressed, msg_formatter_0, msg_in]
- [variable_qtgui_msg_push_button_0_0_0_0_0, pressed, msg_formatter_0_0, msg_in]
- [variable_qtgui_msg_push_button_0_0_0_0_0_0, pressed, msg_formatter_0_0_0, msg_in]
- [virtual_source_0, '0', blocks_message_debug_0, print]
- [virtual_source_0_0, '0', blocks_message_debug_0, print]
- [virtual_source_0_1, '0', root_raised_cosine_filter_0, '0']
- [virtual_source_0_2, '0', blocks_message_debug_0, print]
- [virtual_source_1, '0', qtgui_edit_box_msg_0, val]
- [virtual_source_2, '0', blocks_message_debug_0, print]
- [virtual_source_2_0, '0', blocks_message_debug_0, print]
- [virtual_source_3, '0', rx_fq_win, valuein]
- [zeromq_pull_msg_source_0, out, rx_fq_win, valuein]

metadata:
  file_format: 1
  grc_version: 3.10.5.1
